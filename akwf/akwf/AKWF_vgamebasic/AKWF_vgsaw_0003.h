#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 1, 1, 2, 1, 2, 1, 2, 2, 1, 2, 2,
1, 1, 1, 0, 3, 7, 8, 7, 8, 7, 7, 8, 8, 12, 15, 14, 14, 14, 15, 14, 15, 14, 13,
13, 14, 14, 13, 14, 14, 13, 14, 13, 13, 17, 21, 21, 20, 20, 20, 21, 23, 27, 26,
26, 27, 26, 26, 26, 25, 26, 26, 26, 26, 27, 26, 26, 27, 26, 26, 26, 25, 26, 30,
33, 33, 32, 32, 37, 41, 40, 41, 41, 41, 40, 40, 40, 40, 41, 41, 40, 41, 41, 40,
40, 40, 40, 40, 40, 40, 44, 47, 47, 46, 46, 49, 53, 53, 52, 53, 52, 53, 53, 53,
52, 52, 52, 53, 53, 52, 53, 53, 53, 53, 53, 52, 53, 52, 54, 57, 60, 59, 62, 66,
65, 66, 64, 65, 65, 66, 65, 65, 66, 65, 65, 65, 65, 65, 65, 66, 65, 65, 65, 65,
65, 64, 64, 67, 71, 76, 79, 79, 78, 79, 79, 79, 78, 79, 79, 80, 80, 78, 79, 78,
79, 79, 79, 78, 79, 78, 80, 79, 78, 78, 80, 85, 89, 91, 91, 90, 91, 91, 91, 91,
91, 91, 91, 91, 91, 91, 91, 90, 91, 91, 91, 91, 91, 91, 92, 91, 91, 91, 91, 94,
97, 98, 98, 97, 97, 98, 98, 97, 97, 98, 97, 96, 99, 102, 105, 104, 103, 103,
103, 104, 104, 103, 103, 103, 103, 104, 106, 106, 107, 107, 107, 107, 107, 107,
107, 107, 107, 106, 106, 110, 120, 31, -101, -121, -117, -118, -120, -119, -119,
-119, -119, -120, -119, -115, -107, -108, -108, -109, -108, -108, -108, -109,
-108, -108, -109, -108, -109, -108, -109, -108, -105, -102, -101, -102, -102,
-102, -101, -102, -102, -103, -99, -94, -95, -95, -95, -94, -95, -94, -94, -95,
-94, -94, -94, -95, -94, -95, -94, -91, -88, -87, -88, -88, -88, -89, -88, -89,
-89, -86, -81, -82, -82, -82, -82, -81, -81, -82, -81, -82, -82, -81, -81, -82,
-82, -82, -82, -82, -77, -76, -76, -75, -75, -75, -76, -77, -73, -70, -69, -69,
-70, -70, -69, -70, -69, -69, -70, -70, -70, -69, -69, -69, -69, -69, -70, -71,
-68, -64, -63, -64, -64, -63, -64, -60, -55, -55, -56, -56, -56, -56, -56, -56,
-56, -56, -55, -56, -56, -56, -55, -55, -55, -56, -56, -55, -50, -49, -49, -49,
-50, -50, -48, -44, -42, -44, -43, -43, -43, -44, -44, -44, -43, -44, -43, -43,
-44, -43, -43, -44, -43, -43, -44, -44, -41, -38, -36, -37, -38, -35, -30, -30,
-30, -31, -31, -31, -30, -31, -31, -32, -30, -30, -31, -31, -31, -31, -31, -30,
-31, -30, -31, -31, -31, -27, -25, -25, -23, -17, -16, -17, -17, -17, -17, -17,
-17, -17, -18, -17, -17, -17, -17, -17, -17, -17, -18, -18, -18, -17, -17, -18,
-14, -10, -11, -8, -6, -4, -5, -5, -4, -4, -4, -5, -5, -5, -5, -5, -5, -4, -4,
-5, -5, -4, -5, -5, -5, -5, -4, -5, -4, -1, };