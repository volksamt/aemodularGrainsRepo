#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 11, 10, 10, 10, 10, 10, 10, 9, 10,
15, 20, 21, 20, 19, 19, 20, 26, 30, 30, 30, 29, 30, 29, 29, 30, 30, 30, 29, 30,
30, 29, 33, 40, 42, 41, 41, 41, 41, 41, 41, 40, 42, 48, 56, 60, 62, 61, 62, 60,
61, 61, 62, 62, 62, 61, 61, 60, 67, 73, 73, 73, 73, 72, 73, 73, 73, 72, 73, 73,
72, 73, 79, 84, 83, 82, 83, 82, 83, 83, 83, 83, 83, 83, 83, 83, 82, 87, 93, 95,
95, 94, 94, 93, 94, 94, 93, 95, 102, 108, 114, 115, 114, 114, 113, 115, 114,
114, 114, 114, 114, 114, 114, 113, 115, 115, 115, 114, 114, 114, 117, 120, 119,
119, 119, 118, 118, 113, 109, 109, 109, 109, 109, 109, 108, 108, 109, 109, 109,
109, 110, 110, 106, 99, 99, 99, 99, 99, 99, 99, 100, 100, 99, 91, 84, 78, 77,
78, 78, 77, 78, 78, 78, 78, 78, 77, 77, 78, 78, 78, 77, 78, 78, 79, 78, 72, 68,
67, 68, 68, 69, 66, 60, 55, 56, 56, 56, 56, 56, 56, 56, 56, 56, 56, 57, 54, 48,
46, 46, 46, 46, 47, 47, 46, 46, 46, 48, 45, 40, 31, 25, 24, 25, 25, 24, 25, 25,
25, 25, 25, 25, 24, 25, 24, 26, 24, 25, 25, 21, 15, 15, 15, 15, 14, 14, 15, 15,
7, 5, 5, 4, 5, 6, 5, 6, 5, 5, 4, 5, 7, 3, -3, -6, -5, -5, -4, -6, -5, -5, -4,
-6, -12, -15, -15, -19, -25, -26, -26, -24, -24, -25, -25, -25, -26, -25, -25,
-24, -25, -24, -24, -25, -24, -24, -31, -36, -37, -36, -36, -36, -37, -36, -38,
-44, -48, -46, -46, -46, -46, -46, -46, -46, -47, -47, -47, -45, -49, -56, -57,
-56, -56, -56, -57, -57, -56, -55, -57, -65, -68, -67, -72, -78, -79, -77, -78,
-78, -78, -78, -79, -77, -78, -78, -78, -78, -78, -77, -78, -77, -77, -83, -89,
-88, -87, -87, -88, -88, -86, -89, -97, -100, -99, -99, -99, -99, -100, -99,
-99, -99, -99, -100, -107, -111, -109, -109, -109, -110, -110, -108, -109, -109,
-108, -110, -117, -119, -119, -118, -118, -117, -117, -118, -117, -118, -118,
-117, -117, -117, -117, -117, -118, -118, -117, -118, -113, -108, -106, -108,
-109, -105, -98, -96, -98, -98, -98, -97, -98, -98, -98, -97, -97, -98, -97,
-98, -97, -99, -96, -89, -85, -86, -86, -87, -85, -86, -85, -86, -86, -81, -75,
-75, -76, -76, -71, -66, -66, -66, -66, -66, -67, -67, -66, -67, -66, -66, -66,
-66, -66, -67, -67, -62, -55, -54, -55, -55, -54, -54, -54, -54, -55, -53, -46,
-44, -45, -45, -45, -44, -44, -45, -45, -45, -45, -43, -37, -34, -34, -34, -35,
-35, -34, -35, -36, -35, -27, -22, -23, -24, -23, -18, -13, -13, -13, -13, -14,
-13, -13, -13, -13, -14, -14, -14, -13, -13, -14, -15, -9, -4, -3, -3, -3, -4,
-3, -3, -3, -5, -1, };