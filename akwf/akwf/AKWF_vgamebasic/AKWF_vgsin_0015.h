#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 1, 3, 5, 4, 6, 9, 9, 9, 12, 16,
19, 20, 20, 20, 20, 21, 23, 26, 28, 28, 32, 32, 31, 34, 37, 39, 41, 43, 43, 43,
42, 44, 47, 48, 47, 50, 53, 56, 55, 56, 57, 59, 58, 59, 61, 61, 62, 65, 67, 66,
68, 72, 74, 75, 74, 75, 76, 76, 76, 79, 80, 79, 81, 84, 87, 87, 87, 88, 88, 89,
89, 92, 92, 92, 94, 96, 95, 96, 99, 99, 100, 99, 100, 101, 102, 101, 103, 104,
104, 104, 106, 107, 108, 107, 108, 110, 109, 110, 110, 111, 111, 112, 113, 113,
112, 114, 114, 114, 114, 114, 115, 116, 115, 116, 115, 116, 116, 116, 118, 118,
117, 117, 118, 117, 118, 117, 117, 118, 118, 118, 118, 117, 117, 117, 117, 117,
116, 115, 116, 115, 117, 116, 116, 116, 115, 114, 113, 113, 113, 113, 113, 113,
112, 112, 112, 110, 110, 110, 109, 109, 108, 106, 104, 105, 104, 103, 103, 103,
102, 101, 101, 100, 97, 97, 97, 97, 95, 96, 95, 95, 92, 92, 93, 91, 89, 86, 86,
86, 85, 84, 84, 83, 80, 79, 79, 78, 76, 76, 75, 73, 70, 69, 68, 68, 67, 66, 66,
63, 61, 62, 61, 58, 55, 54, 55, 53, 53, 53, 51, 48, 47, 48, 45, 43, 43, 42, 39,
36, 34, 33, 33, 32, 31, 32, 29, 27, 27, 26, 21, 18, 15, 16, 16, 14, 14, 14, 11,
9, 10, 7, 4, 5, 4, 1, -4, -6, -7, -6, -8, -7, -8, -10, -12, -13, -14, -17, -20,
-22, -22, -23, -25, -25, -25, -28, -30, -31, -31, -34, -35, -35, -37, -41, -44,
-45, -45, -46, -46, -46, -47, -51, -51, -52, -54, -57, -60, -60, -61, -61, -62,
-62, -64, -67, -66, -67, -70, -70, -70, -72, -75, -77, -78, -78, -78, -80, -79,
-79, -84, -84, -84, -85, -88, -90, -91, -91, -91, -92, -92, -93, -94, -94, -96,
-97, -98, -98, -99, -100, -102, -104, -102, -104, -105, -104, -105, -105, -106,
-106, -107, -110, -111, -111, -111, -111, -111, -110, -111, -113, -112, -113,
-114, -114, -114, -114, -116, -116, -118, -117, -117, -118, -117, -118, -118,
-118, -117, -118, -120, -119, -119, -119, -119, -119, -120, -118, -118, -119,
-119, -119, -119, -120, -120, -119, -119, -118, -118, -117, -118, -118, -118,
-116, -116, -116, -116, -116, -116, -114, -114, -113, -113, -112, -113, -112,
-110, -111, -111, -110, -109, -108, -108, -107, -107, -107, -107, -105, -105,
-105, -104, -102, -102, -102, -101, -99, -97, -97, -97, -95, -95, -96, -93, -92,
-91, -92, -89, -87, -87, -85, -85, -85, -84, -85, -82, -79, -80, -78, -77, -77,
-76, -75, -72, -69, -68, -68, -68, -66, -67, -65, -61, -62, -62, -59, -56, -54,
-54, -54, -53, -50, -51, -50, -45, -46, -46, -43, -41, -41, -40, -38, -35, -33,
-34, -32, -30, -31, -29, -26, -25, -26, -23, -20, -17, -16, -15, -15, -12, -13,
-12, -8, -7, -8, -5, -3, -3, -3, };