#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 2, 2, 1, 2, 4, 9, 10, 10, 10,
11, 9, 9, 10, 16, 19, 17, 17, 18, 18, 18, 18, 21, 24, 24, 24, 25, 24, 24, 24,
25, 31, 35, 40, 40, 40, 40, 39, 40, 41, 40, 39, 40, 40, 39, 40, 45, 46, 47, 47,
47, 47, 46, 46, 50, 55, 56, 54, 53, 57, 62, 64, 63, 62, 63, 63, 64, 63, 62, 64,
68, 70, 70, 69, 70, 70, 69, 69, 74, 77, 77, 77, 77, 76, 78, 83, 88, 91, 92, 92,
92, 91, 92, 92, 93, 92, 92, 92, 92, 91, 91, 94, 98, 100, 99, 100, 100, 98, 102,
107, 109, 108, 107, 110, 114, 115, 114, 115, 114, 114, 114, 114, 115, 115, 114,
116, 116, 116, 116, 115, 116, 116, 111, 108, 108, 108, 107, 108, 108, 108, 106,
102, 100, 101, 101, 101, 101, 102, 101, 96, 92, 93, 94, 94, 94, 93, 87, 84, 85,
85, 86, 85, 85, 85, 81, 78, 79, 77, 72, 70, 71, 70, 71, 70, 71, 71, 71, 72, 72,
68, 63, 63, 63, 63, 63, 63, 63, 62, 58, 56, 57, 57, 56, 57, 54, 49, 47, 48, 48,
48, 49, 49, 48, 43, 39, 40, 40, 41, 41, 40, 40, 38, 34, 32, 34, 34, 33, 34, 35,
33, 29, 23, 18, 18, 18, 17, 17, 18, 18, 18, 17, 18, 17, 18, 18, 13, 11, 11, 11,
12, 11, 11, 12, 9, 3, 3, 2, 4, 1, -3, -4, -3, -3, -3, -3, -3, -4, -2, -4, -9,
-10, -10, -9, -10, -9, -9, -9, -14, -18, -19, -17, -18, -18, -17, -22, -28, -32,
-33, -32, -31, -31, -32, -32, -33, -32, -31, -32, -33, -31, -31, -33, -38, -41,
-40, -41, -40, -39, -43, -48, -49, -48, -48, -50, -54, -55, -56, -54, -55, -54,
-55, -55, -55, -54, -54, -57, -63, -63, -63, -62, -62, -62, -66, -71, -71, -71,
-71, -71, -71, -70, -72, -76, -78, -77, -78, -78, -78, -77, -77, -81, -86, -85,
-84, -85, -84, -86, -91, -94, -94, -93, -93, -94, -92, -94, -96, -101, -100,
-102, -107, -109, -108, -108, -107, -107, -108, -108, -108, -108, -114, -117,
-117, -116, -115, -116, -116, -116, -115, -116, -118, -119, -118, -120, -119,
-120, -118, -113, -110, -112, -111, -111, -111, -112, -111, -107, -102, -102,
-103, -103, -103, -103, -104, -101, -97, -95, -96, -96, -97, -97, -97, -97, -92,
-86, -82, -80, -80, -80, -81, -80, -80, -80, -80, -80, -80, -81, -81, -78, -74,
-74, -74, -74, -74, -74, -75, -73, -67, -65, -66, -67, -64, -59, -57, -58, -58,
-58, -58, -58, -57, -58, -57, -53, -50, -51, -52, -52, -51, -51, -52, -48, -44,
-43, -43, -44, -44, -44, -39, -35, -30, -29, -29, -30, -29, -29, -29, -29, -29,
-29, -30, -29, -29, -29, -29, -23, -21, -21, -20, -21, -22, -20, -15, -12, -13,
-13, -12, -8, -6, -7, -6, -6, -7, -6, -6, -6, -7, -7, -5, -1, 1, 1, 0, 0, -1, };