#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 12, 11, 18, 24, 25, 24, 24, 24, 24,
23, 23, 24, 24, 24, 24, 24, 22, 27, 37, 39, 38, 39, 39, 38, 38, 38, 38, 38, 45,
53, 60, 63, 63, 62, 63, 63, 62, 62, 61, 62, 62, 62, 61, 62, 61, 61, 63, 70, 75,
74, 73, 72, 74, 72, 72, 76, 83, 90, 93, 92, 91, 92, 92, 91, 92, 91, 92, 92, 92,
92, 92, 92, 92, 92, 95, 100, 100, 100, 100, 100, 100, 100, 100, 99, 101, 105,
108, 106, 106, 107, 107, 106, 106, 109, 111, 112, 111, 111, 111, 110, 112, 111,
110, 112, 115, 115, 115, 114, 114, 113, 114, 115, 116, 118, 118, 118, 117, 117,
117, 118, 117, 117, 118, 117, 117, 117, 118, 117, 118, 118, 117, 116, 116, 115,
116, 116, 116, 116, 116, 116, 114, 113, 115, 114, 114, 114, 114, 115, 114, 114,
111, 110, 110, 110, 109, 109, 109, 109, 110, 109, 105, 103, 102, 103, 104, 104,
103, 99, 96, 96, 97, 97, 97, 97, 97, 96, 96, 98, 97, 91, 86, 87, 88, 87, 88, 87,
88, 87, 87, 83, 78, 76, 78, 79, 75, 67, 66, 67, 66, 67, 66, 66, 66, 67, 67, 66,
67, 67, 62, 56, 54, 56, 55, 55, 56, 57, 55, 46, 41, 43, 44, 42, 36, 31, 32, 31,
32, 32, 32, 31, 32, 31, 32, 32, 33, 29, 19, 14, 16, 16, 16, 16, 16, 16, 16, 16,
9, 4, 6, 1, -11, -12, -10, -11, -11, -12, -10, -11, -11, -11, -11, -11, -11,
-10, -11, -18, -23, -23, -22, -22, -22, -22, -21, -27, -36, -39, -39, -45, -50,
-50, -49, -49, -49, -49, -49, -49, -50, -49, -49, -49, -49, -48, -53, -61, -63,
-62, -62, -62, -61, -62, -62, -61, -63, -71, -78, -84, -84, -84, -85, -84, -84,
-84, -84, -84, -85, -83, -84, -84, -84, -85, -84, -87, -91, -93, -92, -92, -92,
-91, -92, -92, -96, -101, -105, -107, -107, -107, -106, -106, -107, -106, -106,
-106, -106, -106, -106, -107, -106, -106, -106, -109, -114, -113, -112, -113,
-113, -113, -113, -113, -112, -114, -117, -116, -116, -116, -116, -116, -116,
-116, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -120, -119, -118, -117, -117, -118, -117, -117,
-117, -117, -117, -117, -117, -117, -116, -115, -112, -110, -111, -110, -111,
-111, -111, -111, -111, -111, -112, -111, -111, -109, -107, -106, -106, -107,
-107, -106, -106, -106, -107, -105, -100, -99, -100, -100, -99, -100, -100, -99,
-101, -100, -94, -91, -91, -93, -92, -93, -92, -84, -81, -81, -81, -81, -81,
-81, -82, -81, -81, -82, -81, -75, -73, -72, -73, -74, -72, -73, -74, -69, -61,
-59, -60, -61, -61, -61, -56, -50, -48, -49, -48, -49, -49, -49, -49, -49, -50,
-49, -50, -48, -40, -33, -35, -35, -35, -35, -35, -37, -31, -23, -19, -21, -22,
-20, -11, -7, -8, -8, -8, -8, -8, -9, -7, -8, -7, -8, -9, -3, };