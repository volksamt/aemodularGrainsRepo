#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 5, 6, 6, 5, 7, 10, 11, 11,
14, 18, 20, 21, 21, 23, 24, 23, 26, 28, 28, 29, 33, 34, 33, 35, 38, 41, 43, 43,
43, 44, 44, 46, 49, 49, 50, 52, 55, 58, 60, 58, 60, 61, 59, 61, 64, 66, 65, 67,
69, 73, 73, 73, 74, 74, 74, 75, 77, 77, 78, 81, 83, 82, 83, 85, 88, 89, 89, 89,
91, 90, 91, 92, 94, 93, 95, 97, 99, 99, 99, 99, 100, 100, 101, 103, 104, 104,
103, 105, 105, 105, 108, 109, 110, 109, 110, 109, 109, 109, 110, 111, 111, 112,
112, 113, 115, 114, 114, 114, 115, 114, 115, 116, 117, 116, 116, 116, 116, 117,
118, 117, 117, 117, 117, 117, 117, 118, 118, 117, 117, 118, 118, 118, 117, 118,
117, 116, 116, 116, 116, 116, 116, 115, 115, 114, 114, 114, 113, 113, 112, 112,
111, 111, 111, 110, 110, 110, 109, 108, 107, 106, 106, 106, 105, 105, 104, 104,
103, 103, 102, 100, 100, 100, 98, 97, 95, 95, 95, 94, 94, 94, 92, 90, 91, 89,
88, 85, 84, 84, 85, 83, 84, 83, 80, 77, 78, 77, 75, 74, 75, 73, 70, 67, 67, 67,
66, 65, 65, 64, 61, 61, 61, 57, 54, 53, 52, 52, 51, 48, 50, 47, 44, 45, 44, 40,
39, 39, 39, 36, 34, 31, 32, 31, 29, 25, 24, 24, 25, 24, 22, 19, 15, 13, 15, 14,
11, 12, 10, 8, 6, 7, 5, 1, -2, -4, -4, -4, -6, -5, -8, -10, -12, -11, -14, -15,
-16, -17, -21, -23, -26, -25, -25, -28, -29, -29, -31, -33, -33, -34, -37, -41,
-41, -40, -42, -44, -44, -44, -48, -49, -48, -51, -54, -55, -55, -56, -59, -61,
-62, -62, -64, -64, -64, -66, -68, -67, -68, -72, -75, -76, -76, -76, -77, -78,
-78, -79, -81, -81, -82, -85, -86, -86, -87, -89, -92, -93, -92, -92, -94, -94,
-95, -97, -97, -97, -99, -101, -101, -102, -102, -103, -104, -104, -104, -104,
-104, -104, -106, -109, -107, -108, -109, -111, -112, -111, -111, -113, -112,
-113, -114, -115, -114, -114, -116, -116, -115, -116, -116, -117, -117, -117,
-117, -118, -118, -119, -120, -119, -119, -119, -119, -120, -118, -118, -119,
-119, -118, -120, -119, -119, -119, -119, -119, -117, -117, -118, -117, -118,
-118, -118, -117, -117, -117, -116, -116, -116, -115, -114, -112, -113, -113,
-112, -112, -112, -112, -111, -112, -111, -111, -108, -107, -106, -106, -105,
-104, -105, -104, -103, -104, -102, -101, -99, -100, -99, -98, -96, -95, -95,
-95, -94, -93, -92, -90, -91, -90, -89, -87, -85, -84, -84, -83, -81, -82, -80,
-77, -78, -77, -77, -75, -72, -69, -68, -67, -68, -68, -67, -64, -63, -64, -62,
-60, -61, -58, -56, -53, -51, -51, -50, -49, -49, -49, -47, -44, -45, -44, -40,
-37, -34, -34, -33, -33, -33, -33, -30, -29, -29, -27, -23, -22, -21, -19, -15,
-13, -13, -12, -12, -12, -12, -10, -6, -7, -6, -2, };