#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {64, 124, 115, 116, 118, 119, 115, 111,
109, 111, 110, 111, 110, 110, 110, 109, 110, 111, 110, 110, 110, 110, 110, 110,
111, 111, 112, 111, 111, 112, 112, 112, 112, 111, 111, 112, 111, 111, 111, 111,
112, 111, 112, 112, 111, 111, 111, 111, 111, 112, 112, 112, 111, 111, 112, 111,
112, 111, 112, 111, 112, 112, 111, 112, 112, 112, 111, 111, 111, 111, 111, 111,
112, 112, 111, 111, 112, 111, 111, 111, 111, 112, 112, 112, 111, 112, 111, 112,
111, 111, 111, 111, 112, 111, 111, 112, 111, 111, 112, 112, 112, 111, 111, 112,
111, 111, 112, 112, 111, 111, 111, 112, 112, 111, 112, 111, 111, 111, 112, 112,
112, 111, 112, 112, 111, 112, 111, 112, 111, 111, 111, 112, 112, 112, 111, 111,
112, 111, 112, 112, 112, 112, 112, 111, 112, 112, 112, 111, 112, 111, 111, 111,
111, 111, 111, 111, 112, 111, 111, 111, 112, 112, 111, 111, 112, 111, 111, 111,
111, 112, 112, 111, 112, 111, 111, 111, 112, 112, 112, 112, 112, 111, 111, 111,
111, 111, 112, 111, 112, 112, 111, 111, 111, 111, 111, 112, 111, 111, 111, 112,
111, 111, 111, 112, 112, 111, 111, 111, 111, 111, 111, 112, 112, 112, 112, 111,
111, 111, 112, 112, 111, 111, 111, 112, 111, 111, 112, 111, 111, 112, 112, 111,
110, 110, 110, 110, 110, 110, 111, 109, 111, 113, 112, 113, 114, 113, 113, 107,
102, 102, 103, 102, 100, 104, 122, 62, -75, -121, -106, -103, -103, -104, -103,
-104, -109, -115, -115, -115, -113, -115, -114, -113, -112, -112, -112, -113,
-114, -113, -113, -113, -114, -113, -114, -113, -113, -112, -113, -113, -113,
-114, -113, -113, -114, -114, -114, -113, -113, -113, -114, -113, -112, -113,
-113, -112, -113, -114, -113, -114, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -112, -113, -113, -113, -113, -113, -113, -113, -113, -114,
-114, -112, -113, -113, -113, -113, -113, -112, -113, -113, -113, -112, -112,
-113, -113, -113, -113, -113, -112, -113, -113, -113, -114, -114, -113, -113,
-113, -113, -113, -112, -113, -113, -114, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -114, -113, -114, -113, -112, -113, -113, -113, -114, -113,
-113, -113, -113, -112, -112, -113, -113, -114, -113, -113, -113, -113, -114,
-112, -113, -114, -112, -114, -113, -114, -113, -113, -113, -114, -113, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -114, -113, -113, -113, -113, -113, -113, -113, -113, -113, -112,
-113, -113, -113, -112, -112, -114, -114, -113, -113, -113, -113, -113, -112,
-113, -112, -113, -113, -113, -113, -114, -113, -114, -113, -113, -113, -113,
-113, -113, -113, -113, -113, -113, -114, -112, -114, -113, -113, -113, -113,
-113, -113, -113, -113, -112, -114, -114, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -113, -111, -112, -111, -111, -112, -112, -111, -112, -111,
-112, -112, -112, -111, -112, -112, -110, -113, -117, -120, -119, -118, -116,
-122, -60, };