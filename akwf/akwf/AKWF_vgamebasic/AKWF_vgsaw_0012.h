#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 3, 3, 3, 4, 6, 7, 7, 8, 8, 7,
8, 7, 8, 7, 8, 9, 9, 9, 9, 9, 11, 13, 13, 12, 13, 14, 16, 16, 15, 15, 16, 17,
19, 20, 19, 20, 20, 20, 19, 20, 20, 22, 22, 22, 22, 22, 24, 26, 24, 25, 24, 25,
26, 26, 26, 26, 26, 26, 29, 31, 33, 33, 32, 33, 32, 33, 32, 33, 34, 34, 34, 34,
35, 36, 37, 38, 37, 37, 37, 39, 38, 38, 38, 40, 41, 42, 42, 43, 44, 43, 44, 43,
44, 43, 43, 45, 46, 47, 46, 46, 47, 50, 50, 49, 49, 50, 51, 51, 51, 51, 52, 54,
55, 54, 55, 56, 56, 56, 55, 55, 55, 58, 59, 59, 59, 59, 59, 60, 61, 60, 60, 60,
61, 62, 64, 63, 62, 63, 65, 67, 66, 67, 68, 68, 68, 68, 68, 68, 69, 71, 71, 71,
72, 71, 72, 73, 73, 73, 72, 72, 75, 76, 75, 75, 76, 77, 79, 79, 79, 80, 80, 81,
80, 80, 81, 82, 83, 83, 84, 83, 83, 84, 85, 85, 85, 86, 86, 88, 88, 88, 88, 89,
90, 90, 89, 89, 91, 93, 93, 93, 93, 92, 93, 95, 96, 97, 95, 96, 97, 98, 97, 97,
97, 99, 100, 101, 100, 100, 101, 102, 102, 102, 102, 102, 105, 105, 105, 105,
106, 105, 105, 105, 105, 105, 106, 106, 111, 112, 111, 111, 112, 117, 116, 117,
120, 97, -10, -75, -61, -53, -60, -99, -119, -119, -118, -119, -113, -107, -108,
-108, -109, -109, -111, -112, -111, -111, -109, -104, -104, -105, -105, -106,
-105, -105, -105, -106, -106, -106, -104, -102, -102, -102, -102, -101, -99,
-99, -99, -99, -98, -98, -97, -98, -97, -97, -94, -94, -94, -94, -94, -93, -93,
-93, -93, -93, -91, -90, -88, -88, -89, -87, -88, -89, -89, -88, -89, -88, -86,
-85, -85, -85, -85, -83, -82, -81, -82, -81, -81, -80, -80, -81, -81, -79, -78,
-77, -76, -75, -75, -76, -76, -77, -76, -75, -73, -73, -73, -73, -72, -72, -72,
-71, -71, -72, -72, -70, -69, -67, -69, -69, -67, -66, -65, -63, -63, -63, -63,
-64, -64, -64, -63, -62, -60, -60, -61, -61, -60, -59, -59, -58, -60, -58, -56,
-55, -56, -56, -56, -56, -55, -53, -52, -51, -52, -51, -51, -51, -52, -52, -50,
-48, -47, -48, -48, -47, -47, -46, -47, -46, -46, -43, -42, -43, -44, -42, -41,
-43, -42, -40, -38, -38, -39, -38, -39, -39, -40, -38, -37, -38, -37, -37, -37,
-35, -34, -34, -35, -33, -32, -30, -31, -31, -32, -30, -29, -29, -29, -26, -25,
-26, -27, -26, -27, -26, -25, -24, -25, -25, -24, -22, -22, -22, -22, -22, -22,
-21, -21, -20, -20, -21, -19, -18, -16, -17, -15, -14, -14, -13, -14, -15, -13,
-13, -12, -12, -13, -12, -10, -9, -9, -9, -10, -8, -8, -8, -8, -8, -7, -5, -5,
-5, -4, -5, -3, -3, -3, -3, -4, -4, -1, -1, 1, 0, 0, };