#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 83, 110, 109, 110, 109, 110, 108,
106, 106, 106, 105, 104, 104, 105, 105, 106, 105, 105, 104, 102, 102, 102, 103,
102, 103, 103, 103, 104, 103, 104, 103, 103, 103, 103, 104, 103, 104, 103, 104,
104, 103, 104, 103, 104, 103, 104, 105, 104, 103, 104, 104, 104, 104, 104, 104,
104, 104, 104, 103, 103, 104, 103, 103, 103, 103, 103, 104, 104, 103, 103, 103,
104, 104, 103, 104, 104, 103, 103, 104, 104, 104, 104, 104, 104, 104, 104, 103,
104, 104, 104, 104, 103, 104, 104, 103, 104, 104, 104, 103, 103, 103, 103, 104,
103, 103, 104, 104, 103, 104, 103, 104, 103, 104, 103, 103, 103, 103, 103, 104,
104, 104, 104, 103, 104, 103, 104, 103, 104, 104, 104, 104, 104, 104, 103, 104,
103, 104, 104, 103, 104, 104, 104, 104, 103, 104, 103, 104, 104, 104, 104, 104,
104, 104, 104, 104, 103, 103, 104, 103, 103, 104, 104, 103, 104, 104, 103, 103,
104, 104, 104, 104, 104, 104, 103, 103, 104, 104, 104, 104, 103, 103, 103, 104,
104, 104, 104, 104, 104, 104, 104, 103, 103, 104, 104, 104, 104, 103, 104, 103,
104, 104, 104, 104, 103, 104, 103, 104, 104, 104, 103, 104, 104, 103, 103, 104,
104, 104, 104, 104, 104, 103, 104, 103, 104, 103, 104, 104, 103, 103, 105, 106,
104, 103, 103, 102, 102, 102, 102, 103, 102, 103, 101, 101, 99, 99, 103, 111,
110, 110, 108, 112, 115, 123, 83, -62, -124, -112, -110, -108, -104, -99, -101,
-101, -103, -102, -104, -103, -104, -103, -103, -103, -104, -105, -107, -106,
-106, -107, -106, -105, -105, -106, -104, -106, -105, -104, -105, -105, -105,
-105, -105, -106, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105,
-105, -105, -105, -105, -105, -105, -105, -104, -105, -105, -105, -105, -105,
-105, -105, -105, -105, -105, -105, -106, -105, -106, -105, -105, -105, -105,
-106, -104, -106, -105, -105, -106, -105, -105, -105, -105, -105, -105, -105,
-105, -105, -105, -105, -105, -105, -105, -105, -105, -106, -105, -106, -105,
-105, -106, -105, -105, -104, -105, -105, -105, -105, -105, -104, -105, -105,
-105, -106, -105, -105, -105, -105, -105, -106, -106, -105, -105, -105, -106,
-105, -105, -105, -106, -105, -105, -105, -106, -105, -105, -105, -105, -104,
-105, -106, -105, -106, -105, -105, -105, -106, -105, -105, -104, -105, -105,
-106, -105, -105, -105, -104, -105, -106, -105, -105, -106, -104, -105, -106,
-105, -105, -104, -104, -105, -104, -105, -105, -105, -105, -105, -105, -105,
-105, -106, -105, -105, -104, -105, -105, -104, -104, -105, -104, -105, -106,
-105, -104, -105, -105, -105, -105, -105, -106, -105, -105, -105, -105, -105,
-105, -104, -105, -105, -105, -105, -105, -105, -105, -105, -106, -105, -105,
-105, -105, -104, -104, -105, -106, -105, -105, -105, -105, -106, -105, -104,
-104, -103, -103, -104, -104, -106, -106, -107, -106, -107, -107, -106, -106,
-107, -106, -107, -109, -110, -112, -109, -100, -100, -102, -53, 2, 8, -5, -8,
};