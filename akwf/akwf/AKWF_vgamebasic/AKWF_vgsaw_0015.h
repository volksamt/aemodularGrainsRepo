#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 1, 2, 2, 1, 1, 3, 5, 5, 4, 4,
4, 4, 6, 8, 8, 8, 8, 9, 9, 9, 10, 11, 11, 12, 13, 14, 14, 15, 14, 14, 14, 14,
15, 16, 16, 16, 18, 17, 17, 18, 20, 21, 20, 21, 21, 22, 22, 23, 24, 24, 24, 24,
26, 27, 26, 27, 26, 27, 26, 28, 29, 27, 29, 30, 30, 30, 30, 31, 33, 33, 33, 34,
35, 35, 35, 36, 35, 36, 37, 39, 40, 40, 39, 39, 39, 39, 40, 41, 41, 40, 42, 43,
42, 44, 44, 45, 46, 46, 46, 46, 47, 48, 49, 49, 48, 49, 50, 52, 52, 52, 52, 52,
52, 52, 53, 52, 53, 54, 55, 55, 55, 57, 57, 58, 58, 58, 59, 59, 60, 61, 61, 61,
61, 63, 64, 64, 64, 64, 64, 65, 64, 66, 66, 66, 67, 68, 67, 68, 69, 70, 71, 70,
71, 72, 72, 72, 73, 74, 73, 74, 75, 76, 77, 77, 77, 76, 77, 77, 78, 78, 79, 79,
79, 82, 82, 81, 83, 83, 83, 84, 84, 84, 84, 86, 86, 87, 87, 88, 89, 90, 89, 89,
90, 89, 89, 91, 92, 91, 91, 93, 93, 95, 95, 95, 96, 95, 95, 97, 97, 98, 98, 98,
99, 98, 100, 101, 102, 101, 102, 102, 102, 101, 102, 103, 103, 104, 105, 106,
106, 104, 105, 107, 108, 108, 110, 111, 111, 112, 113, 113, 114, 115, 116, 118,
120, 119, 109, 109, 117, 44, -58, -68, -63, -96, -112, -110, -108, -111, -116,
-118, -118, -116, -114, -115, -113, -113, -113, -113, -111, -109, -108, -108,
-108, -107, -107, -107, -106, -104, -105, -105, -104, -103, -102, -102, -102,
-101, -102, -102, -101, -100, -101, -100, -99, -99, -100, -98, -97, -97, -96,
-96, -95, -95, -94, -94, -92, -93, -92, -92, -91, -90, -89, -89, -90, -90, -90,
-90, -88, -89, -88, -86, -86, -87, -86, -85, -84, -83, -82, -83, -81, -81, -81,
-81, -79, -80, -80, -79, -77, -77, -76, -77, -77, -76, -75, -75, -75, -75, -75,
-73, -74, -73, -72, -71, -70, -71, -70, -70, -70, -69, -68, -67, -68, -67, -65,
-65, -64, -64, -65, -63, -64, -63, -63, -63, -62, -63, -61, -61, -59, -59, -59,
-58, -58, -58, -57, -56, -56, -55, -55, -56, -55, -54, -53, -51, -51, -51, -52,
-52, -52, -51, -50, -51, -50, -49, -48, -46, -47, -47, -46, -45, -46, -45, -44,
-44, -43, -43, -42, -42, -42, -41, -39, -39, -39, -39, -40, -40, -38, -37, -38,
-38, -36, -36, -35, -35, -35, -33, -32, -33, -32, -32, -31, -31, -30, -29, -29,
-29, -29, -27, -26, -26, -27, -27, -26, -26, -26, -25, -25, -24, -24, -22, -21,
-22, -21, -21, -20, -20, -18, -19, -19, -18, -17, -17, -16, -16, -15, -14, -13,
-15, -14, -15, -15, -13, -12, -12, -12, -11, -10, -9, -10, -9, -8, -8, -8, -7,
-6, -7, -5, -5, -4, -4, -4, -2, -1, -2, -2, -2, -2, -1, -1, -1, 0, };