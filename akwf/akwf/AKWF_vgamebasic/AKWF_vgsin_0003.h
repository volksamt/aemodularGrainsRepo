#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 6, 5, 4, 5, 4, 4, 5, 5, 4, 5, 6, 5,
4, 5, 5, 4, 5, 5, 4, 5, 6, 5, 4, 12, 26, 39, 46, 45, 44, 45, 45, 45, 44, 44, 44,
45, 45, 44, 44, 44, 44, 44, 45, 44, 45, 44, 44, 45, 44, 44, 52, 64, 75, 79, 78,
77, 77, 78, 78, 78, 77, 78, 78, 78, 78, 78, 78, 78, 77, 78, 77, 78, 78, 78, 77,
77, 77, 76, 79, 89, 95, 93, 94, 93, 93, 94, 93, 93, 94, 94, 93, 93, 97, 103,
103, 103, 103, 104, 103, 103, 103, 103, 103, 103, 102, 105, 110, 112, 111, 111,
111, 111, 111, 112, 112, 111, 111, 111, 111, 111, 112, 114, 116, 116, 115, 116,
116, 116, 116, 116, 116, 115, 116, 117, 118, 118, 118, 118, 118, 117, 117, 117,
118, 117, 117, 117, 117, 117, 118, 116, 114, 115, 114, 114, 114, 114, 114, 114,
115, 112, 108, 108, 107, 108, 108, 108, 108, 108, 107, 108, 108, 108, 109, 108,
109, 108, 105, 99, 98, 98, 99, 98, 98, 99, 99, 100, 96, 88, 86, 88, 87, 87, 87,
87, 88, 87, 87, 87, 87, 87, 87, 87, 86, 88, 87, 78, 70, 72, 72, 71, 70, 72, 73,
67, 55, 53, 55, 54, 53, 54, 54, 54, 54, 54, 54, 54, 54, 54, 54, 54, 54, 53, 55,
51, 40, 35, 37, 37, 38, 38, 30, 15, 12, 15, 14, 14, 14, 14, 14, 14, 14, 13, 14,
14, 14, 14, 15, 14, 14, 16, 11, -4, -8, -7, -6, -5, -4, -13, -26, -27, -25, -25,
-25, -26, -25, -26, -26, -25, -26, -25, -25, -25, -25, -26, -25, -25, -26, -25,
-24, -35, -47, -47, -44, -45, -54, -64, -65, -63, -64, -63, -64, -64, -63, -63,
-63, -63, -64, -64, -63, -64, -64, -64, -63, -63, -63, -64, -63, -64, -75, -79,
-78, -86, -95, -96, -95, -95, -95, -96, -96, -96, -96, -95, -95, -95, -96, -95,
-95, -95, -95, -95, -96, -95, -95, -95, -97, -103, -105, -105, -109, -114, -113,
-113, -113, -112, -113, -113, -113, -113, -113, -112, -113, -113, -113, -112,
-112, -112, -113, -112, -113, -113, -113, -112, -112, -114, -118, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118,
-116, -116, -115, -116, -116, -116, -115, -116, -115, -116, -116, -116, -114,
-110, -109, -109, -109, -109, -110, -109, -110, -110, -110, -110, -111, -109,
-104, -99, -100, -101, -100, -100, -101, -100, -100, -101, -100, -100, -100,
-100, -101, -94, -88, -88, -89, -89, -89, -89, -89, -88, -88, -90, -88, -78,
-71, -73, -73, -74, -73, -74, -73, -73, -73, -73, -73, -73, -74, -73, -63, -54,
-56, -56, -56, -55, -56, -56, -55, -55, -58, -54, -43, -37, -38, -38, -39, -38,
-38, -39, -37, -39, -38, -38, -39, -37, -38, -41, -35, -19, -13, -16, -16, -16,
-16, -16, -16, -19, -13, 0, };