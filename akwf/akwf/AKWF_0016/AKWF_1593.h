#define DATA_LENGTH 512
#define DATA AKWF_1593

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 9, 10, 12, 15, 16, 18, 19,
22, 24, 24, 26, 27, 29, 30, 32, 34, 35, 37, 38, 40, 41, 43, 45, 46, 48, 48, 51,
52, 54, 56, 57, 58, 61, 61, 64, 65, 67, 68, 70, 71, 74, 75, 77, 79, 80, 82, 83,
85, 86, 89, 90, 91, 93, 94, 96, 97, 99, 100, 101, 103, 104, 106, 106, 107, 108,
109, 111, 110, 112, 113, 113, 114, 114, 115, 116, 115, 117, 116, 117, 117, 117,
118, 117, 118, 118, 118, 119, 119, 118, 119, 118, 119, 118, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 120, 119, 120, 120, 118, 119, 118, 119, 119, 119,
117, 118, 117, 117, 116, 116, 115, 116, 115, 114, 114, 114, 112, 112, 111, 110,
110, 110, 109, 109, 108, 108, 107, 105, 106, 105, 104, 104, 103, 102, 102, 101,
100, 100, 100, 100, 99, 98, 98, 97, 97, 95, 95, 94, 94, 92, 93, 92, 91, 90, 89,
89, 88, 88, 87, 86, 85, 84, 84, 83, 83, 81, 80, 80, 79, 78, 77, 76, 76, 75, 73,
73, 71, 70, 69, 68, 66, 66, 64, 62, 61, 59, 58, 57, 55, 54, 53, 51, 50, 49, 47,
45, 45, 43, 42, 41, 41, 38, 38, 36, 36, 35, 34, 33, 32, 30, 30, 28, 28, 26, 25,
24, 24, 23, 22, 21, 20, 18, 18, 17, 17, 15, 15, 13, 13, 11, 11, 11, 9, 8, 7, 7,
5, 5, 5, 3, 3, 1, 1, 0, -1, -2, -3, -5, -5, -5, -7, -8, -9, -9, -10, -11, -12,
-13, -14, -14, -15, -16, -17, -18, -18, -19, -21, -22, -23, -23, -25, -26, -27,
-28, -28, -29, -31, -32, -32, -33, -35, -36, -36, -38, -39, -40, -41, -42, -44,
-45, -47, -48, -49, -50, -52, -52, -55, -55, -57, -58, -59, -62, -63, -65, -66,
-67, -68, -69, -71, -72, -72, -74, -75, -75, -77, -78, -79, -79, -80, -80, -81,
-82, -83, -84, -84, -86, -86, -86, -87, -89, -88, -89, -90, -91, -91, -92, -93,
-94, -94, -94, -96, -96, -97, -98, -98, -99, -99, -100, -101, -101, -102, -102,
-102, -103, -104, -104, -104, -105, -105, -107, -107, -107, -108, -110, -110,
-111, -111, -111, -113, -112, -114, -114, -114, -115, -115, -115, -116, -116,
-117, -118, -118, -117, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -120, -119, -118, -119, -119, -119,
-119, -118, -118, -118, -119, -118, -118, -117, -118, -117, -118, -117, -117,
-116, -116, -116, -115, -115, -114, -114, -113, -113, -112, -111, -110, -110,
-108, -108, -106, -105, -104, -102, -101, -100, -98, -97, -95, -94, -92, -92,
-90, -87, -87, -84, -83, -81, -80, -79, -77, -75, -73, -72, -70, -68, -66, -65,
-63, -62, -60, -59, -58, -55, -54, -51, -51, -49, -47, -45, -45, -42, -41, -40,
-38, -37, -36, -33, -32, -31, -29, -28, -25, -25, -23, -21, -19, -17, -16, -14,
-13, -11, -9, -7, -5, -2, -1, };