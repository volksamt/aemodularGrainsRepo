#define DATA_LENGTH 512
#define DATA AKWF_1585

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 67, 74, 74, 80, 83, 90, 96, 105,
110, 117, 117, 120, 117, 113, 106, 100, 93, 88, 84, 82, 82, 83, 84, 86, 87, 87,
86, 85, 83, 78, 76, 72, 69, 66, 65, 65, 65, 65, 66, 66, 66, 65, 64, 63, 62, 59,
57, 56, 55, 53, 53, 53, 53, 53, 53, 53, 54, 53, 52, 51, 51, 48, 49, 47, 47, 46,
47, 45, 47, 46, 47, 45, 48, 34, -33, -59, -58, -62, -62, -64, -64, -66, -66,
-68, -67, -69, -70, -69, -70, -71, -71, -72, -72, -72, -73, -72, -73, -72, -73,
-73, -73, -73, -72, -72, -72, -72, -72, -71, -70, -71, -70, -69, -69, -69, -68,
-68, -67, -68, -67, -67, -65, -65, -65, -64, -63, -62, -62, -61, -60, -60, -59,
-58, -58, -57, -57, -55, -54, -54, -53, -52, -52, -51, -51, -50, -50, -49, -49,
-47, -46, -45, -45, -43, -43, -42, -42, -41, -40, -40, -39, -39, -38, -38, -36,
-35, -35, -34, -33, -33, -33, -31, -31, -30, -29, -28, -28, -27, -27, -26, -25,
-25, -24, -24, -23, -22, -22, -22, -20, -21, -20, -19, -19, -18, -17, -17, -16,
-15, -15, -14, -14, -14, -13, -13, -12, -12, -11, -10, -11, -10, -10, -9, -8,
-7, -7, -6, -7, -7, -5, -5, -5, -4, -4, -3, -4, -3, -2, -3, -2, -2, -1, -1, 0,
0, 0, 0, 1, 1, 2, 2, 2, 3, 3, 3, 3, 4, 5, 5, 4, 5, 5, 5, 6, 6, 6, 6, 6, 7, 7, 7,
7, 8, 8, 8, 9, 8, 8, 8, 9, 9, 9, 9, 9, 9, 10, 10, 10, 11, 11, 10, 10, 11, 11,
12, 12, 11, 12, 11, 12, 11, 12, 12, 11, 12, 12, 12, 12, 13, 13, 12, 13, 12, 12,
12, 13, 12, 13, 12, 13, 13, 13, 13, 13, 13, 14, 13, 13, 12, 13, 13, 12, 13, 13,
13, 13, 13, 12, 13, 12, 13, 12, 12, 13, 12, 13, 12, 13, 13, 12, 13, 12, 12, 12,
12, 12, 12, 12, 12, 12, 13, 12, 12, 11, 11, 12, 11, 11, 11, 11, 11, 11, 11, 10,
10, 10, 11, 11, 10, 11, 10, 10, 10, 9, 10, 9, 9, 9, 9, 9, 10, 9, 9, 9, 9, 9, 9,
8, 8, 8, 8, 8, 7, 7, 8, 7, 6, 7, 6, 6, 6, 6, 6, 6, 6, 6, 6, 5, 5, 5, 5, 4, 4, 5,
4, 4, 4, 4, 4, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 1, 2, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0,
0, -1, 0, 0, -1, -1, -1, -1, -2, -2, -2, -3, -3, -4, -3, -3, -3, -3, -4, -4, -4,
-4, -5, -5, -4, -5, -5, -5, -6, -6, -7, -6, -6, -6, -7, -7, -7, -8, -9, -9, -8,
-8, -9, -8, -9, -9, -10, -9, -10, -10, -10, -10, -11, -11, -11, -11, -12, -12,
-11, -13, -12, -12, -13, -13, -13, -14, -13, -14, -14, -15, -13, -16, -17, };