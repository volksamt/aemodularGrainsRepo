#define DATA_LENGTH 512
#define DATA AKWF_1591

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 30, 34, 40, 42, 49, 51, 57, 59,
67, 64, 62, 65, 65, 66, 66, 74, 75, 73, 72, 70, 69, 67, 66, 65, 63, 61, 60, 58,
57, 55, 54, 52, 52, 48, 49, 44, 51, 60, 56, 57, 57, 58, 57, 57, 59, 57, 34, 29,
28, 24, 23, 19, 18, 14, 12, 8, 6, 15, 16, 14, 15, 13, 12, 12, 15, 14, 16, 15,
17, 16, 18, 18, 19, 19, 20, 20, 22, 21, 23, 22, 25, 22, 28, 15, 0, 4, -33, -33,
-29, -26, -21, -20, -15, -12, -7, -6, -2, 1, 5, 8, 12, 14, 19, 22, 26, 29, 32,
35, 40, 42, 45, 49, 52, 56, 59, 69, 70, 68, 69, 69, 69, 68, 69, 68, 68, 68, 68,
67, 68, 68, 67, 68, 68, 66, 53, 54, 51, 52, 48, 23, 18, 19, 14, 15, 8, 12, -7,
-30, -19, -17, -9, -5, 25, 52, 51, 61, 62, 79, 107, 109, 116, 118, 101, 96, 93,
89, 86, 82, 77, 74, 70, 66, 62, 59, 55, 52, 48, 44, 39, 37, 31, 35, 45, 38, 36,
31, 28, 26, 18, 26, 32, 30, 36, 33, 12, -19, -46, -56, -52, -49, -48, -46, -45,
-43, -44, -35, -27, -28, -25, -25, -23, -23, -20, -19, -18, -17, -16, -15, -13,
-11, -11, -9, -8, -6, -5, -4, -3, -2, 1, 2, 3, 4, 6, 8, 8, 9, 11, 13, 13, 15,
16, 17, 19, 20, 22, 23, 25, 26, 27, 29, 29, 30, 33, 33, 29, 24, 20, 16, 13, 8,
5, -1, -6, -5, -6, -6, -5, -6, -5, -5, -5, -7, -6, -6, -6, -7, -5, -6, -6, -7,
-6, -6, -7, -5, -7, -6, -8, -3, -37, -47, -40, -42, -32, -20, -25, -18, -28,
-63, -54, -53, -46, -43, -39, -35, -31, -23, -32, -56, -67, -63, -65, -65, -67,
-66, -67, -68, -70, -69, -71, -71, -73, -73, -74, -73, -74, -75, -77, -77, -78,
-78, -80, -80, -81, -82, -83, -83, -85, -84, -86, -86, -87, -88, -69, -68, -65,
-65, -59, -62, -48, -14, -10, -30, -43, -37, -39, -36, -37, -34, -35, -32, -34,
-30, -43, -48, -38, -44, -43, -46, -46, -49, -47, -41, -44, -51, -54, -61, -65,
-70, -74, -79, -84, -89, -94, -99, -105, -107, -116, -99, -87, -71, -34, -12,
-8, -12, -11, -14, -12, -16, -14, -19, -13, -31, -60, -50, -51, -45, -44, -31,
-7, -5, 6, 9, 22, 40, 43, 51, 33, 24, 24, 19, 16, 12, 10, 6, 3, -1, -4, -8, -11,
-14, -18, -21, -24, -29, -32, -35, -38, -41, -46, -48, -52, -54, -59, -62, -65,
-67, -56, -56, -57, -56, -59, -58, -60, -59, -61, -61, -62, -62, -63, -63, -64,
-64, -64, -65, -66, -66, -67, -67, -68, -70, -69, -70, -71, -71, -72, -73, -73,
-73, -75, -75, -75, -76, -76, -77, -78, -78, -80, -86, -84, -81, -80, -78, -76,
-72, -72, -69, -68, -65, -64, -61, -60, -57, -56, -53, -52, -49, -47, -44, -44,
-40, -4, };