#define DATA_LENGTH 512
#define DATA AKWF_1517

const PROGMEM int8_t DATA[DATA_LENGTH] = {81, 97, 90, 95, 89, 94, 90, 94, 91,
94, 91, 93, 91, 93, 91, 92, 92, 93, 92, 92, 92, 93, 92, 92, 92, 92, 93, 91, 92,
92, 92, 92, 92, 93, 91, 92, 92, 92, 91, 93, 91, 93, 92, 92, 91, 92, 92, 92, 92,
92, 92, 92, 92, 90, 93, 90, 97, 41, 23, 30, 26, 29, 27, 29, 27, 29, 26, 30, 22,
104, 125, 115, 122, 116, 121, 117, 121, 118, 120, 118, 120, 118, 120, 118, 120,
118, 119, 119, 119, 120, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 115,
116, 116, 116, 116, 116, 115, 116, 116, 116, 115, 115, 116, 115, 116, 116, 116,
115, 115, 115, 116, 114, 117, 113, 117, 112, 118, 112, 122, 98, 45, 53, 48, 52,
51, 50, 50, 50, 51, 50, 50, 50, 51, 49, 52, 49, 51, 50, 51, 49, 51, 48, 30, 30,
32, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 29,
27, 28, 27, 29, 27, 28, 28, 28, 27, 27, 27, 27, 28, 28, 27, 28, 28, 28, 28, 28,
28, 28, 25, 23, 24, 23, 24, 24, 23, 24, 24, 23, 24, 23, 23, 24, 24, 24, 24, 24,
23, 24, 22, 24, 23, 25, 22, 26, 18, 2, 4, 4, 5, 4, 5, 4, 4, 4, 4, 4, 4, 4, 4, 5,
4, 4, 4, 4, 5, 4, 5, 4, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, -3, -4, -4, -5, -4, -4, -4, -4, -4, -4, -4, -4, -4, -5, -4, -4, -4, -4,
-4, -3, -3, -5, -2, -20, -26, -23, -24, -23, -24, -23, -24, -23, -23, -24, -24,
-23, -25, -24, -24, -23, -24, -24, -24, -24, -24, -23, -23, -24, -23, -24, -28,
-28, -28, -28, -28, -28, -27, -27, -27, -27, -27, -28, -28, -28, -27, -27, -28,
-28, -28, -27, -28, -27, -28, -31, -31, -32, -31, -32, -32, -31, -31, -31, -31,
-31, -31, -31, -31, -31, -31, -32, -31, -31, -31, -31, -49, -51, -49, -50, -49,
-51, -49, -51, -49, -51, -49, -51, -49, -51, -49, -51, -50, -51, -50, -51, -52,
-46, -102, -120, -112, -118, -113, -117, -113, -117, -115, -117, -114, -116,
-115, -116, -115, -116, -116, -115, -115, -116, -115, -115, -116, -116, -116,
-116, -115, -115, -116, -116, -119, -118, -119, -119, -119, -118, -119, -118,
-119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -118, -121, -118,
-120, -117, -121, -117, -121, -116, -122, -114, -127, -98, -20, -31, -26, -29,
-27, -29, -27, -30, -26, -32, -22, -46, -98, -89, -95, -91, -93, -92, -92, -92,
-92, -92, -92, -92, -92, -93, -91, -93, -92, -92, -92, -92, -91, -93, -92, -92,
-92, -91, -91, -91, -92, -91, -92, -91, -92, -91, -92, -92, -92, -92, -92, -92,
-92, -92, -92, -92, -91, -93, -91, -94, -91, -94, -90, -94, -90, -95, -87, -98,
-78, };