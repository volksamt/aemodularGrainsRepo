#define DATA_LENGTH 512
#define DATA AKWF_1511

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 25, 23, 25, 23, 23, 24, 24, 24,
23, 23, 24, 24, 24, 23, 24, 24, 24, 24, 25, 23, 25, 24, 25, 23, 24, 23, 24, 22,
26, 22, 32, 50, 47, 48, 48, 48, 47, 48, 48, 47, 47, 48, 48, 48, 47, 47, 48, 48,
48, 47, 48, 48, 47, 47, 47, 48, 46, 71, 96, 94, 95, 96, 95, 95, 95, 95, 95, 95,
95, 96, 96, 95, 96, 96, 96, 96, 96, 95, 96, 95, 95, 95, 96, 96, 95, 96, 96, 95,
96, 94, 95, 95, 96, 94, 95, 95, 94, 115, 120, 118, 120, 118, 120, 119, 119, 119,
120, 119, 120, 118, 120, 120, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 120, 119, 120,
119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 118, 119, 119, 119, 120, 119,
118, 119, 117, 92, 105, 124, 100, 94, 96, 95, 96, 96, 94, 96, 94, 99, 84, 68,
74, 70, 73, 71, 72, 71, 71, 71, 72, 70, 72, 70, 73, 69, 47, 48, 47, 48, 48, 47,
48, 48, 48, 47, 47, 48, 48, 47, 48, 47, 48, 46, 48, 47, 49, 46, 50, 42, 22, 24,
24, 24, 24, 23, 24, 24, 24, 23, 23, 24, 24, 25, 24, 23, 25, 23, 23, 24, 24, 23,
24, 24, 23, 24, 24, 23, 23, 23, 24, 24, 25, 24, 24, 24, 25, 23, 25, 22, 26, 14,
-3, 2, -1, 2, -2, 3, -14, -26, -22, -26, -24, -24, -23, -24, -24, -25, -24, -24,
-24, -24, -24, -23, -23, -24, -23, -23, -23, -24, -24, -25, -24, -24, -23, -24,
-24, -24, -23, -24, -24, -24, -24, -23, -23, -24, -23, -23, -25, -23, -44, -49,
-46, -49, -47, -48, -47, -49, -48, -49, -47, -49, -47, -49, -47, -48, -47, -48,
-48, -48, -47, -49, -47, -47, -69, -72, -71, -72, -71, -72, -71, -72, -72, -73,
-70, -73, -71, -73, -68, -85, -98, -94, -96, -95, -96, -96, -95, -95, -94, -102,
-125, -102, -93, -118, -119, -118, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120,
-119, -118, -119, -119, -118, -119, -119, -118, -118, -119, -119, -120, -119,
-119, -119, -118, -119, -118, -119, -119, -120, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -120, -118, -120, -117, -121, -114, -94, -96, -95,
-95, -95, -95, -95, -94, -95, -96, -95, -95, -95, -95, -95, -95, -95, -95, -95,
-95, -95, -95, -95, -96, -95, -95, -94, -95, -95, -95, -95, -96, -94, -95, -95,
-95, -95, -95, -96, -69, -45, -49, -48, -47, -48, -48, -48, -48, -48, -48, -48,
-47, -47, -47, -48, -47, -47, -47, -47, -47, -48, -49, -47, -49, -46, -50, -31,
-22, -24, -23, -24, -23, -25, -23, -24, -24, -23, -24, -24, -23, -24, -23, -24,
-24, -24, -24, -24, -24, -25, -24, -25, -24, -25, -24, -25, -22, -25, -21, };