#define DATA_LENGTH 512
#define DATA AKWF_1503

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 13, 16, 20, 24, 27, 31, 33,
36, 37, 38, 41, 43, 43, 45, 47, 48, 50, 50, 53, 54, 56, 57, 59, 61, 62, 63, 65,
67, 69, 70, 73, 74, 76, 78, 80, 82, 84, 86, 89, 90, 92, 95, 97, 99, 101, 103,
105, 107, 109, 111, 113, 114, 114, 115, 115, 115, 116, 116, 117, 117, 117, 117,
118, 118, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119,
120, 119, 119, 118, 119, 118, 118, 118, 118, 118, 118, 117, 118, 118, 118, 117,
116, 117, 117, 117, 117, 117, 117, 117, 116, 117, 117, 117, 118, 117, 117, 117,
117, 118, 118, 119, 117, 117, 118, 117, 116, 116, 115, 115, 114, 113, 114, 113,
112, 112, 112, 111, 112, 111, 111, 111, 110, 109, 110, 109, 109, 109, 108, 109,
108, 108, 108, 108, 107, 107, 107, 106, 107, 106, 106, 106, 105, 104, 105, 105,
105, 104, 104, 104, 104, 103, 103, 102, 101, 100, 100, 100, 99, 98, 98, 98, 96,
95, 95, 93, 93, 92, 91, 90, 89, 88, 87, 86, 84, 83, 81, 80, 79, 77, 77, 76, 74,
71, 69, 66, 63, 61, 57, 54, 52, 48, 45, 42, 39, 38, 35, 35, 32, 30, 30, 27, 27,
25, 23, 22, 20, 19, 17, 16, 14, 12, 12, 11, 9, 7, 6, 4, 4, 2, 2, 1, 0, -1, -1,
-2, -3, -3, -3, -2, -3, -3, -2, -2, -1, -1, -1, 0, 0, -1, 0, 0, 1, 1, 0, 2, 1,
1, 1, 1, 2, 2, 2, 3, 3, 2, 2, 1, 1, 1, 0, -1, -2, -4, -4, -6, -7, -8, -10, -11,
-13, -14, -15, -17, -19, -21, -21, -23, -24, -26, -28, -29, -31, -33, -33, -35,
-38, -40, -42, -46, -49, -51, -55, -58, -61, -64, -67, -70, -72, -74, -75, -77,
-78, -79, -81, -82, -84, -84, -85, -87, -88, -89, -90, -91, -91, -93, -94, -95,
-95, -96, -97, -97, -98, -99, -100, -100, -100, -101, -102, -103, -103, -103,
-104, -104, -104, -105, -105, -105, -105, -105, -105, -106, -106, -107, -106,
-107, -107, -108, -107, -108, -107, -108, -108, -108, -109, -108, -110, -109,
-110, -110, -111, -111, -110, -111, -112, -112, -112, -113, -113, -114, -114,
-114, -114, -115, -116, -116, -117, -117, -118, -118, -118, -118, -118, -117,
-117, -117, -116, -117, -117, -117, -117, -117, -117, -116, -116, -117, -118,
-117, -117, -117, -117, -117, -117, -118, -117, -117, -119, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -120, -118, -119, -120, -119,
-119, -120, -119, -119, -118, -118, -118, -118, -118, -117, -117, -117, -117,
-116, -116, -116, -116, -116, -114, -113, -113, -111, -109, -107, -105, -103,
-101, -98, -97, -94, -93, -91, -88, -86, -84, -82, -80, -78, -77, -74, -72, -70,
-69, -67, -65, -64, -62, -60, -58, -57, -55, -53, -52, -51, -49, -48, -46, -45,
-43, -41, -41, -39, -38, -35, -33, -31, -27, -23, -21, -16, -13, -9, -5, -2, };