#define DATA_LENGTH 512
#define DATA AKWF_1572

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 69, 114, 120, 118, 118, 117, 116,
116, 115, 115, 114, 114, 115, 114, 113, 114, 112, 112, 112, 112, 111, 111, 111,
111, 111, 109, 110, 109, 108, 108, 108, 108, 107, 107, 107, 107, 106, 105, 106,
105, 104, 104, 104, 103, 103, 103, 103, 103, 102, 102, 102, 101, 100, 100, 100,
100, 99, 99, 98, 98, 98, 97, 98, 97, 97, 96, 97, 96, 97, 96, 95, 94, 94, 94, 94,
94, 94, 94, 93, 92, 92, 92, 91, 92, 91, 92, 90, 91, 90, 89, 90, 89, 89, 89, 88,
88, 88, 88, 88, 87, 87, 87, 86, 74, 26, -27, -42, -41, -39, -40, -39, -38, -38,
-37, -32, 15, 83, 109, 108, 107, 107, 107, 107, 105, 106, 105, 106, 104, 104,
103, 104, 103, 103, 102, 103, 102, 100, 102, 99, 102, 97, 103, 93, 111, 44, -22,
-5, -15, -9, -14, -10, -14, -11, -14, -13, -13, -14, -14, -15, -14, -16, -15,
-16, -15, -17, -17, -17, -17, -18, -18, -18, -18, -19, -19, -19, -20, -21, -21,
-21, -20, -21, -22, -22, -23, -22, -23, -23, -23, -23, -24, -24, -24, -24, -24,
-25, -26, -26, -25, -26, -26, -27, -26, -27, -28, -27, -28, -28, -28, -29, -28,
-30, -29, -30, -29, -30, -31, -31, -31, -30, -30, -31, -31, -31, -33, -32, -32,
-33, -33, -34, -33, -33, -34, -33, -34, -34, -35, -34, -35, -34, -35, -36, -36,
-36, -35, -36, -36, -37, -37, -36, -37, -38, -38, -38, -38, -39, -39, -38, -39,
-40, -39, -40, -40, -40, -40, -40, -41, -41, -41, -41, -41, -41, -42, -42, -42,
-43, -42, -42, -42, -42, -43, -44, -43, -44, -44, -44, -44, -44, -45, -45, -45,
-45, -45, -45, -46, -46, -46, -46, -45, -46, -45, -46, -47, -47, -48, -47, -47,
-46, -47, -47, -48, -48, -47, -48, -49, -48, -49, -49, -50, -49, -50, -49, -49,
-49, -50, -50, -50, -50, -50, -51, -51, -51, -50, -51, -50, -53, -50, -53, -51,
-53, -50, -55, -48, -61, -34, 56, 56, 56, 56, 55, 56, 54, 56, 54, 55, 54, 55,
55, 56, 50, 14, -52, -88, -90, -88, -88, -87, -86, -86, -85, -84, -83, -83, -81,
-81, -81, -80, -79, -78, -78, -77, -77, -76, -75, -74, -74, -74, -72, -71, -71,
-70, -69, -69, -68, -68, -68, -66, -65, -66, -65, -64, -64, -63, -62, -62, -61,
-61, -59, -60, -59, -58, -57, -56, -57, -55, -55, -55, -54, -54, -53, -53, -52,
-52, -51, -50, -50, -49, -48, -48, -47, -47, -46, -45, -46, -44, -44, -43, -43,
-43, -42, -41, -41, -40, -40, -39, -39, -39, -38, -38, -37, -36, -35, -35, -34,
-35, -33, -33, -34, -32, -32, -32, -31, -30, -30, -29, -29, -28, -28, -28, -27,
-27, -27, -27, -25, -25, -25, -24, -23, -23, -22, -22, -22, -21, -21, -20, -20,
-20, -20, -19, -18, -18, -18, -17, -16, -17, -16, -16, -16, -15, -14, -14, -15,
-14, -13, -13, -12, -12, -12, -11, -9, -11, -6, };