#define DATA_LENGTH 512
#define DATA AKWF_1584

const PROGMEM int8_t DATA[DATA_LENGTH] = {44, 74, 69, 76, 78, 87, 93, 102, 107,
116, 117, 121, 115, 117, 95, 22, -14, -19, -27, -30, -32, -32, -32, -31, -29,
-29, -30, -32, -35, -39, -42, -46, -50, -53, -54, -55, -56, -55, -53, -52, -52,
-52, -53, -54, -55, -57, -58, -59, -60, -60, -59, -60, -59, -58, -57, -56, -56,
-55, -55, -55, -56, -55, -56, -55, -55, -55, -54, -53, -52, -51, -50, -49, -48,
-48, -48, -47, -46, -45, -46, -45, -44, -44, -42, -41, -41, -40, -39, -38, -38,
-36, -36, -35, -35, -34, -33, -34, -32, -31, -30, -30, -29, -28, -27, -27, -26,
-26, -24, -23, -23, -22, -21, -21, -20, -19, -19, -18, -17, -17, -16, -15, -15,
-14, -13, -13, -13, -12, -12, -11, -10, -10, -9, -8, -7, -7, -6, -5, -5, -5, -4,
-3, -3, -3, -3, -2, -1, 0, 0, 1, 1, 2, 3, 3, 3, 4, 5, 4, 5, 5, 5, 6, 6, 7, 6, 7,
8, 8, 8, 9, 10, 9, 10, 10, 11, 11, 11, 11, 13, 13, 13, 13, 14, 14, 14, 14, 14,
15, 15, 15, 16, 16, 16, 16, 17, 17, 18, 18, 17, 17, 17, 18, 18, 19, 18, 19, 18,
19, 20, 20, 20, 20, 20, 21, 20, 21, 21, 21, 20, 21, 21, 22, 21, 22, 21, 22, 22,
22, 22, 22, 23, 22, 23, 22, 23, 22, 23, 23, 23, 22, 23, 24, 24, 22, 23, 23, 23,
23, 23, 23, 22, 23, 23, 23, 23, 23, 24, 24, 23, 24, 24, 23, 23, 23, 23, 23, 23,
24, 23, 24, 24, 23, 23, 23, 23, 23, 23, 22, 22, 23, 22, 22, 23, 23, 23, 22, 22,
22, 23, 22, 22, 21, 22, 22, 22, 21, 22, 22, 21, 21, 21, 21, 20, 20, 20, 20, 21,
21, 20, 19, 20, 19, 19, 19, 19, 19, 19, 19, 18, 18, 19, 17, 19, 18, 18, 17, 17,
17, 17, 17, 17, 17, 17, 17, 15, 17, 16, 16, 16, 16, 15, 15, 16, 15, 15, 15, 15,
14, 13, 14, 14, 13, 13, 13, 13, 12, 13, 13, 12, 11, 11, 12, 12, 11, 11, 10, 10,
11, 10, 9, 10, 10, 9, 9, 9, 9, 9, 9, 8, 8, 7, 8, 8, 7, 7, 6, 6, 7, 6, 6, 6, 6,
5, 5, 5, 5, 5, 5, 4, 4, 4, 3, 3, 3, 3, 3, 2, 2, 2, 3, 2, 1, 1, 0, 1, 0, 1, 0, 0,
0, -1, 0, -1, -1, -2, -3, -2, -2, -2, -2, -3, -3, -3, -4, -3, -4, -4, -4, -5,
-5, -5, -5, -5, -6, -7, -7, -6, -6, -7, -8, -8, -8, -9, -8, -9, -9, -9, -9, -10,
-10, -10, -10, -10, -11, -11, -11, -11, -12, -13, -12, -12, -12, -12, -13, -13,
-13, -14, -13, -14, -15, -15, -15, -15, -16, -15, -15, -16, -17, -17, -16, -18,
-17, -17, -17, -17, -18, -19, -19, -19, -20, -19, -20, -19, -20, -21, -21, -21,
-22, -20, -22, -21, -21, -25, -5, };