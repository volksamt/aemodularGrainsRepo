#define DATA_LENGTH 512
#define DATA AKWF_1558

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 5, 8, 9, 12, 14, 16, 17, 19, 19,
21, 21, 23, 24, 24, 26, 25, 26, 27, 28, 29, 28, 29, 29, 29, 30, 30, 30, 30, 31,
30, 30, 31, 31, 31, 31, 31, 31, 31, 32, 32, 31, 31, 31, 32, 32, 32, 32, 32, 31,
31, 32, 32, 31, 32, 32, 32, 32, 31, 32, 31, 32, 32, 32, 31, 32, 31, 32, 32, 32,
31, 32, 32, 32, 31, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 31, 31, 31, 32, 31,
31, 32, 31, 32, 31, 31, 32, 32, 32, 32, 32, 32, 31, 31, 31, 31, 32, 31, 31, 31,
31, 31, 31, 31, 30, 32, 31, 31, 32, 31, 32, 31, 31, 31, 31, 32, 31, 32, 32, 31,
31, 31, 31, 31, 31, 31, 32, 30, 32, 31, 32, 30, 31, 31, 31, 31, 32, 30, 31, 31,
32, 30, 32, 31, 31, 31, 31, 31, 30, 32, 29, 32, 28, 33, 28, 35, 24, 38, 20, 48,
-4, -128, -113, -122, -118, -119, -118, -118, -119, -118, -120, -119, -119,
-118, -120, -119, -120, -118, -119, -119, -119, -120, -118, -119, -118, -119,
-118, -120, -118, -120, -118, -119, -118, -118, -120, -116, -121, -50, -89,
-101, -72, -74, -55, -56, -40, -40, -29, -27, -18, -16, -10, -8, -3, -1, 3, 6,
8, 10, 12, 14, 15, 17, 18, 20, 20, 22, 23, 24, 24, 25, 25, 27, 27, 27, 27, 27,
28, 29, 28, 29, 30, 29, 29, 30, 30, 29, 30, 30, 31, 30, 31, 31, 31, 31, 31, 31,
31, 31, 32, 31, 31, 32, 31, 31, 31, 31, 31, 31, 31, 32, 31, 31, 32, 32, 31, 31,
32, 31, 31, 31, 31, 31, 31, 32, 32, 31, 30, 31, 32, 31, 32, 32, 30, 31, 32, 32,
31, 31, 32, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 30, 31, 31, 31, 31, 31, 32,
31, 31, 31, 31, 31, 32, 31, 32, 31, 31, 31, 31, 31, 31, 31, 31, 30, 31, 31, 31,
31, 31, 31, 32, 31, 31, 30, 31, 31, 30, 31, 31, 31, 31, 30, 31, 31, 31, 31, 30,
30, 30, 31, 30, 30, 30, 31, 31, 31, 30, 31, 30, 31, 30, 31, 29, 31, 29, 31, 30,
31, 30, 30, 31, 29, 33, 25, 45, -54, -126, -115, -122, -116, -121, -117, -122,
-117, -120, -118, -121, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -120, -118, -120, -118, -121, -118, -119, -118, -120, -117,
-120, -118, -120, -118, -119, -118, -118, -119, -117, -120, -116, -121, -114,
-125, -108, -128, -39, 49, 20, 37, 26, 34, 29, 34, 30, 33, 31, 31, 31, 31, 33,
31, 32, 31, 32, 30, 32, 30, 32, 30, 32, 31, 32, 31, 32, 31, 32, 31, 32, 32, 31,
31, 30, 32, 32, 32, 31, 32, 31, 32, 31, 32, 30, 32, 30, 34, 11, -85, -104, -83,
-76, -63, -57, -47, -42, -33, -29, -22, -18, -12, -9, -6, -3, 0, };