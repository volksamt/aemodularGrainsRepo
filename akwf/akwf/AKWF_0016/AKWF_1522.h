#define DATA_LENGTH 512
#define DATA AKWF_1522

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 13, 16, 19, 22, 23, 27, 28,
30, 33, 36, 37, 41, 41, 44, 44, 49, 48, 52, 52, 57, 56, 63, 61, 69, 68, 77, 111,
66, 63, 67, 64, 68, 65, 68, 67, 69, 67, 69, 68, 69, 68, 69, 69, 68, 70, 65, 48,
47, 43, 41, 39, 38, 37, 35, 34, 33, 32, 30, 30, 29, 30, 27, 27, 27, 27, 25, 25,
25, 24, 23, 23, 22, 22, 22, 21, 21, 21, 20, 20, 20, 19, 19, 19, 19, 18, 18, 18,
18, 18, 17, 18, 17, 17, 16, 17, 16, 17, 17, 16, 17, 17, 17, 17, 17, 16, 16, 16,
17, 16, 16, 17, 17, 16, 16, 16, 16, 16, 16, 16, 17, 16, 17, 16, 16, 17, 17, 16,
16, 16, 17, 16, 17, 16, 16, 15, 16, 17, 16, 16, 15, 16, 16, 16, 16, 16, 16, 16,
16, 17, 15, 15, 16, 15, 16, 15, 16, 15, 15, 15, 15, 14, 15, 15, 15, 16, 14, 16,
15, 15, 15, 15, 14, 15, 15, 16, 14, 15, 14, 15, 14, 15, 14, 14, 14, 14, 13, 14,
14, 14, 14, 13, 15, 12, 32, 46, 46, 52, 54, 57, 58, 60, 61, 64, 64, 67, 66, 68,
69, 70, 71, 71, 73, 73, 74, 74, 76, 76, 76, 77, 77, 77, 79, 79, 80, 79, 80, 79,
81, 81, 81, 81, 82, 81, 81, 82, 82, 83, 81, 83, 82, 83, 82, 84, 81, 83, 80, 84,
75, 36, 27, 19, 15, 11, 5, 2, -1, -3, -7, -9, -12, -13, -16, -17, -21, -21, -24,
-25, -27, -28, -31, -32, -33, -34, -36, -37, -38, -40, -41, -43, -45, -47, -48,
-54, -69, -69, -71, -70, -70, -71, -72, -72, -72, -73, -74, -74, -72, -73, -73,
-74, -72, -76, -67, -53, -51, -47, -45, -44, -42, -42, -40, -38, -37, -37, -36,
-36, -33, -33, -32, -32, -31, -30, -29, -29, -29, -29, -27, -28, -27, -26, -26,
-26, -26, -25, -26, -24, -25, -24, -23, -23, -23, -22, -23, -22, -22, -22, -21,
-22, -22, -22, -21, -21, -21, -21, -21, -20, -21, -21, -20, -20, -21, -20, -21,
-21, -21, -21, -20, -21, -20, -21, -20, -20, -20, -20, -20, -20, -20, -20, -20,
-20, -20, -19, -20, -20, -19, -19, -20, -19, -19, -19, -19, -19, -19, -19, -19,
-18, -19, -18, -19, -18, -19, -18, -18, -18, -18, -19, -17, -17, -18, -17, -17,
-18, -18, -18, -17, -17, -17, -16, -17, -17, -16, -16, -16, -16, -17, -17, -16,
-16, -16, -16, -15, -16, -15, -15, -16, -15, -15, -16, -14, -15, -14, -15, -15,
-14, -14, -14, -14, -13, -15, -12, -34, -46, -47, -52, -53, -57, -57, -60, -60,
-63, -64, -65, -65, -67, -67, -68, -69, -70, -70, -71, -72, -72, -72, -74, -73,
-74, -74, -75, -76, -75, -76, -76, -76, -76, -77, -77, -76, -77, -77, -77, -76,
-77, -77, -77, -76, -77, -76, -77, -76, -77, -75, -77, -74, -78, -65, -25, -19,
-11, -6, -2, };