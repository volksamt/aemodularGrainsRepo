#define DATA_LENGTH 512
#define DATA AKWF_1554

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 8, 8, 10, 10, 11, 13, 13,
13, 14, 15, 15, 16, 16, 17, 17, 17, 17, 18, 18, 18, 18, 18, 18, 19, 19, 20, 19,
19, 18, 19, 19, 19, 20, 19, 20, 20, 20, 19, 19, 20, 20, 19, 20, 20, 19, 20, 20,
19, 20, 19, 20, 20, 20, 20, 20, 19, 20, 19, 20, 20, 20, 20, 20, 20, 20, 20, 20,
20, 20, 19, 20, 20, 19, 20, 20, 19, 20, 19, 19, 20, 20, 19, 20, 19, 19, 19, 19,
19, 20, 19, 20, 19, 19, 19, 19, 20, 19, 19, 19, 19, 20, 19, 19, 20, 19, 20, 19,
19, 19, 20, 19, 19, 20, 20, 20, 20, 19, 20, 19, 19, 19, 19, 19, 19, 19, 19, 19,
19, 20, 19, 20, 19, 19, 19, 20, 18, 20, 20, 20, 19, 19, 18, 20, 12, -79, -106,
-83, -80, -68, -63, -51, -47, -40, -36, -30, -26, -21, -18, -15, -11, -9, -7,
-4, -1, 0, 2, 4, 5, 6, 8, 8, 10, 10, 12, 12, 12, 14, 14, 15, 15, 15, 16, 15, 16,
17, 17, 17, 17, 17, 18, 18, 17, 17, 19, 18, 18, 18, 18, 19, 18, 19, 18, 19, 18,
18, 19, 20, 18, 19, 18, 19, 19, 18, 18, 18, 19, 19, 19, 19, 18, 19, 19, 19, 19,
20, 19, 19, 19, 19, 19, 18, 19, 19, 20, 19, 19, 19, 19, 18, 19, 19, 19, 19, 18,
19, 19, 18, 19, 19, 19, 18, 19, 19, 19, 19, 19, 19, 19, 18, 18, 19, 19, 19, 18,
19, 18, 19, 18, 19, 19, 19, 19, 18, 19, 19, 19, 19, 19, 19, 19, 19, 18, 19, 19,
19, 18, 19, 19, 18, 18, 18, 17, 18, 19, 18, 18, 19, 18, 18, 18, 18, 18, 19, 19,
18, 18, 19, 18, 18, 20, 17, 20, 18, 19, 18, 20, 17, 20, 18, 19, 17, 19, 18, 18,
18, 17, 19, 16, 22, 11, 32, -80, -128, -111, -125, -114, -123, -116, -122, -117,
-121, -118, -120, -118, -120, -119, -120, -119, -119, -119, -119, -119, -118,
-119, -118, -120, -118, -119, -118, -120, -118, -120, -119, -119, -118, -119,
-117, -119, -118, -119, -119, -118, -118, -117, -119, -116, -121, -116, -122,
-112, -127, -39, 38, 10, 24, 16, 22, 18, 20, 18, 20, 19, 19, 20, 18, 19, 18, 21,
19, 20, 18, 20, 19, 19, 19, 19, 18, 19, 19, 20, 19, 19, 19, 20, 19, 19, 19, 19,
20, 19, 19, 19, 19, 20, 20, 19, 20, 20, 19, 19, 19, 19, 19, 19, 20, 19, 20, 19,
19, 19, 19, 20, 20, 19, 19, 19, 19, 19, 20, 20, 19, 20, 19, 19, 19, 20, 19, 20,
18, 19, 19, 19, 19, 19, 19, 20, 19, 19, 18, 20, 19, 18, 19, 19, 19, 19, 20, 19,
20, 19, 20, 19, 20, 19, 20, 17, 24, 0, -89, -100, -85, -79, -68, -60, -53, -47,
-40, -35, -30, -26, -21, -18, -14, -11, -9, -6, -2, -1, };