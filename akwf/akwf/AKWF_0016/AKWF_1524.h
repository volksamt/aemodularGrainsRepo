#define DATA_LENGTH 512
#define DATA AKWF_1524

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 17, 21, 27, 31, 36, 40, 45,
50, 54, 59, 63, 67, 72, 76, 80, 85, 89, 93, 97, 100, 103, 106, 107, 110, 110,
112, 112, 113, 114, 115, 115, 116, 117, 117, 118, 118, 119, 118, 118, 118, 119,
119, 119, 119, 119, 118, 118, 117, 117, 116, 114, 112, 112, 110, 108, 106, 105,
103, 100, 99, 97, 95, 94, 92, 90, 88, 87, 85, 84, 81, 78, 77, 74, 72, 69, 67,
65, 63, 61, 58, 57, 56, 56, 54, 53, 50, 49, 48, 46, 43, 42, 40, 37, 35, 33, 30,
27, 25, 22, 20, 17, 14, 12, 10, 8, 5, 3, 0, -2, -4, -5, -8, -9, -11, -13, -14,
-16, -18, -19, -21, -21, -23, -24, -25, -26, -27, -28, -28, -30, -30, -31, -33,
-34, -35, -36, -37, -37, -39, -39, -39, -40, -41, -39, -40, -40, -40, -41, -40,
-42, -42, -44, -45, -47, -48, -49, -51, -52, -54, -56, -57, -59, -61, -64, -65,
-67, -69, -71, -72, -74, -76, -76, -77, -78, -79, -80, -79, -78, -78, -77, -75,
-75, -75, -74, -72, -71, -70, -70, -69, -68, -68, -67, -66, -66, -65, -63, -62,
-62, -60, -59, -59, -58, -58, -56, -54, -54, -52, -52, -52, -50, -50, -50, -50,
-50, -49, -48, -48, -47, -46, -44, -43, -43, -42, -42, -40, -40, -39, -39, -37,
-37, -37, -35, -34, -34, -34, -32, -31, -31, -29, -28, -27, -25, -24, -22, -21,
-19, -17, -15, -13, -11, -9, -6, -4, 0, 2, 5, 6, 9, 11, 13, 15, 17, 19, 21, 22,
24, 26, 26, 28, 29, 31, 32, 32, 34, 34, 34, 35, 36, 37, 37, 39, 39, 39, 41, 41,
42, 43, 43, 45, 46, 47, 48, 49, 49, 50, 50, 50, 50, 52, 51, 52, 52, 53, 55, 56,
56, 57, 58, 60, 61, 61, 63, 65, 65, 65, 67, 68, 68, 69, 69, 70, 71, 72, 73, 73,
74, 76, 77, 77, 78, 79, 78, 80, 79, 78, 79, 77, 75, 74, 72, 70, 69, 67, 66, 64,
61, 60, 57, 55, 54, 52, 50, 49, 48, 46, 45, 44, 42, 42, 41, 40, 40, 40, 40, 40,
40, 40, 40, 39, 39, 37, 37, 36, 35, 33, 32, 31, 31, 29, 28, 27, 26, 26, 25, 24,
22, 22, 20, 19, 18, 16, 14, 13, 10, 10, 7, 5, 4, 1, -1, -3, -5, -8, -10, -12,
-14, -17, -20, -23, -25, -29, -30, -33, -36, -37, -39, -42, -44, -46, -48, -49,
-51, -53, -53, -55, -57, -58, -59, -61, -63, -65, -68, -70, -72, -74, -76, -79,
-81, -83, -84, -87, -88, -90, -92, -93, -95, -97, -99, -100, -102, -105, -106,
-108, -110, -112, -114, -114, -116, -116, -118, -119, -118, -119, -119, -118,
-118, -118, -118, -118, -118, -119, -118, -117, -118, -117, -116, -115, -114,
-114, -113, -113, -111, -111, -109, -107, -105, -103, -99, -96, -93, -89, -84,
-80, -76, -71, -67, -63, -59, -54, -50, -46, -41, -36, -31, -26, -21, -16, -11,
-7, -2, };