#define DATA_LENGTH 512
#define DATA AKWF_1528

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 18, 21, 24, 26, 28, 30,
33, 35, 35, 37, 37, 38, 39, 39, 40, 40, 40, 39, 39, 38, 37, 36, 35, 34, 34, 33,
32, 31, 31, 29, 28, 27, 25, 24, 23, 22, 21, 20, 20, 19, 19, 19, 20, 19, 18, 18,
18, 17, 17, 18, 18, 17, 18, 19, 19, 21, 22, 23, 24, 26, 27, 28, 29, 31, 32, 33,
35, 37, 39, 41, 43, 46, 50, 52, 55, 58, 61, 64, 67, 70, 73, 75, 80, 83, 85, 89,
94, 97, 100, 104, 105, 106, 106, 105, 104, 104, 102, 102, 101, 99, 98, 98, 97,
95, 95, 94, 92, 92, 91, 91, 90, 88, 87, 86, 87, 85, 84, 84, 83, 82, 81, 81, 80,
79, 78, 77, 76, 76, 75, 74, 74, 73, 73, 72, 71, 71, 70, 69, 68, 68, 68, 67, 65,
65, 65, 63, 63, 63, 63, 61, 61, 60, 60, 59, 59, 58, 57, 57, 56, 56, 56, 56, 54,
53, 54, 53, 53, 52, 51, 51, 50, 50, 50, 49, 48, 48, 47, 47, 46, 46, 46, 46, 44,
44, 43, 44, 44, 43, 43, 42, 41, 41, 41, 40, 40, 39, 38, 39, 39, 38, 38, 37, 38,
36, 36, 35, 35, 35, 35, 35, 35, 34, 34, 34, 33, 32, 32, 31, 32, 32, 31, 31, 30,
30, 30, 30, 29, 29, 29, 29, 28, 28, 28, 28, 26, 27, 27, 26, 25, 25, 22, 20, 18,
16, 14, 12, 10, 9, 7, 5, 4, 3, 2, 1, 1, 1, 1, 2, 2, 2, 3, 4, 5, 6, 7, 9, 10, 12,
14, 16, 17, 20, 21, 21, 22, 22, 22, 22, 22, 21, 22, 21, 21, 21, 21, 20, 21, 20,
20, 20, 20, 20, 20, 19, 19, 19, 19, 18, 18, 18, 17, 18, 18, 17, 17, 16, 16, 12,
10, 8, 4, 1, -4, -7, -11, -14, -18, -22, -26, -30, -34, -38, -42, -46, -48, -52,
-56, -59, -62, -65, -69, -72, -75, -77, -80, -83, -85, -87, -89, -91, -91, -93,
-94, -95, -96, -97, -97, -96, -97, -97, -96, -97, -96, -96, -95, -95, -97, -101,
-106, -111, -115, -118, -119, -119, -119, -118, -117, -116, -114, -113, -113,
-112, -110, -109, -108, -108, -106, -105, -104, -104, -102, -101, -100, -99,
-99, -98, -96, -95, -95, -94, -93, -92, -91, -89, -90, -88, -88, -87, -86, -85,
-85, -83, -83, -82, -81, -80, -80, -78, -79, -77, -77, -76, -75, -75, -74, -74,
-73, -71, -71, -70, -70, -69, -68, -67, -67, -66, -66, -64, -65, -64, -64, -63,
-61, -61, -61, -61, -61, -60, -59, -58, -58, -57, -56, -56, -56, -55, -54, -54,
-54, -53, -53, -52, -52, -51, -51, -50, -50, -49, -48, -48, -47, -48, -46, -45,
-45, -45, -45, -45, -43, -43, -43, -42, -43, -42, -42, -41, -41, -41, -40, -39,
-40, -39, -39, -37, -38, -38, -37, -36, -37, -35, -36, -36, -35, -35, -35, -35,
-34, -33, -33, -31, -28, -25, -22, -17, -13, -8, -5, -1, };