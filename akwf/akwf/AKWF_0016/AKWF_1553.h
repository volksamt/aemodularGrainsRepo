#define DATA_LENGTH 512
#define DATA AKWF_1553

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 7, 8, 9, 10, 10, 11, 11,
13, 13, 13, 14, 15, 15, 15, 16, 16, 17, 17, 16, 16, 18, 17, 18, 17, 18, 18, 18,
18, 18, 18, 18, 18, 19, 18, 18, 18, 18, 18, 18, 19, 19, 18, 19, 19, 18, 19, 19,
18, 18, 18, 19, 19, 19, 19, 19, 19, 19, 19, 18, 18, 18, 18, 18, 18, 19, 18, 19,
19, 19, 18, 18, 18, 19, 19, 19, 19, 19, 18, 18, 19, 18, 18, 18, 19, 18, 19, 18,
18, 18, 19, 18, 18, 18, 18, 19, 18, 19, 19, 18, 18, 19, 18, 18, 19, 19, 18, 18,
19, 19, 19, 19, 18, 18, 18, 19, 18, 18, 18, 18, 18, 18, 19, 18, 18, 18, 18, 18,
19, 19, 17, 19, 18, 18, 18, 18, 18, 18, 18, 18, 19, 18, 18, 18, 18, 17, 18, 18,
19, 19, 18, 18, 19, 18, 18, 17, 19, 18, 18, 17, 18, 17, 22, 7, -87, -122, -116,
-121, -118, -121, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -119, -118, -119, -118, -119, -119,
-119, -119, -119, -118, -118, -119, -117, -118, -118, -119, -117, -120, -117,
-121, -116, -122, -114, -123, -111, -128, -87, 23, 16, 21, 18, 19, 20, 19, 20,
18, 20, 19, 20, 18, 20, 18, 20, 19, 20, 19, 19, 19, 20, 20, 20, 19, 19, 19, 19,
19, 19, 20, 20, 20, 19, 20, 19, 19, 19, 20, 19, 20, 20, 19, 19, 19, 19, 20, 19,
19, 20, 19, 20, 19, 20, 20, 19, 19, 19, 19, 20, 19, 19, 20, 19, 20, 19, 19, 19,
19, 20, 19, 19, 19, 19, 19, 20, 19, 19, 19, 19, 19, 19, 19, 19, 20, 19, 19, 19,
18, 20, 20, 20, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 18,
19, 19, 20, 18, 19, 19, 18, 19, 19, 19, 18, 20, 19, 21, -54, -109, -91, -85,
-73, -66, -58, -51, -44, -39, -34, -28, -24, -20, -17, -13, -11, -8, -6, -2, 0,
1, 3, 6, 7, 7, 8, 9, 10, 11, 12, 14, 14, 14, 15, 15, 16, 15, 17, 17, 17, 18, 17,
18, 18, 18, 18, 19, 18, 17, 18, 19, 18, 18, 18, 18, 18, 19, 18, 18, 19, 19, 19,
20, 19, 20, 19, 19, 19, 19, 19, 19, 19, 19, 20, 20, 19, 19, 19, 20, 19, 19, 19,
19, 19, 19, 20, 18, 20, 19, 19, 19, 19, 19, 19, 19, 20, 20, 19, 19, 19, 19, 19,
19, 19, 19, 19, 18, 20, 20, 20, 19, 19, 19, 18, 20, 19, 19, 19, 19, 20, 20, 19,
18, 19, 19, 19, 18, 20, 19, 19, 19, 19, 18, 19, 19, 19, 19, 19, 18, 19, 19, 19,
19, 19, 19, 19, 20, 18, 20, 17, 22, -50, -109, -89, -84, -71, -66, -56, -50,
-43, -38, -33, -28, -24, -20, -16, -12, -11, -7, -6, -3, -1, };