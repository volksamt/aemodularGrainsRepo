#define DATA_LENGTH 512
#define DATA AKWF_1559

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 10, 11, 14, 16, 18, 19, 21,
22, 23, 24, 25, 25, 27, 28, 28, 29, 30, 29, 30, 31, 31, 31, 32, 32, 32, 32, 33,
33, 33, 33, 33, 33, 34, 33, 34, 33, 34, 35, 34, 34, 33, 34, 34, 34, 34, 34, 34,
35, 34, 35, 34, 34, 34, 34, 34, 34, 34, 35, 34, 33, 33, 34, 34, 35, 35, 34, 35,
34, 35, 35, 35, 35, 35, 34, 34, 34, 35, 34, 34, 35, 34, 35, 34, 35, 34, 34, 34,
34, 34, 35, 33, 35, 35, 35, 34, 35, 33, 34, 34, 34, 34, 34, 34, 34, 34, 34, 34,
34, 34, 34, 34, 35, 34, 35, 34, 34, 33, 34, 34, 34, 34, 33, 34, 34, 33, 34, 33,
34, 34, 33, 33, 34, 33, 33, 33, 34, 34, 33, 34, 33, 33, 34, 34, 34, 33, 33, 33,
34, 33, 34, 32, 34, 33, 33, 33, 34, 33, 34, 32, 34, 32, 34, 32, 34, 32, 35, 31,
37, 21, -89, -124, -115, -121, -118, -121, -117, -119, -119, -120, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -118, -119,
-118, -119, -118, -120, -119, -118, -119, -118, -118, -117, -119, -117, -120,
-116, -122, -115, -123, -111, -128, -73, -62, -110, -74, -77, -59, -55, -43,
-38, -30, -25, -19, -15, -11, -5, -3, 3, 4, 9, 10, 14, 14, 18, 18, 21, 20, 23,
23, 25, 25, 26, 27, 28, 29, 29, 29, 30, 31, 30, 31, 32, 32, 32, 33, 32, 34, 33,
34, 33, 34, 34, 34, 34, 34, 34, 34, 34, 34, 34, 35, 35, 34, 34, 34, 35, 35, 35,
35, 35, 35, 34, 35, 35, 34, 34, 34, 35, 34, 35, 35, 34, 35, 34, 35, 35, 34, 35,
34, 34, 35, 34, 35, 35, 34, 34, 35, 35, 35, 35, 34, 35, 35, 34, 35, 35, 35, 34,
34, 34, 35, 34, 34, 34, 35, 35, 35, 35, 35, 34, 34, 34, 35, 34, 34, 34, 34, 35,
35, 34, 35, 34, 34, 34, 34, 34, 34, 35, 34, 34, 35, 34, 34, 35, 34, 34, 34, 33,
34, 34, 34, 34, 34, 35, 34, 33, 34, 34, 35, 33, 34, 34, 34, 33, 34, 34, 33, 34,
34, 34, 34, 34, 33, 33, 33, 33, 34, 34, 33, 34, 33, 35, 33, 35, 32, 37, 30, 40,
-17, -113, -118, -120, -118, -119, -118, -119, -119, -120, -120, -119, -119,
-119, -119, -119, -120, -118, -120, -119, -119, -118, -119, -118, -119, -118,
-119, -118, -118, -118, -118, -119, -119, -118, -118, -119, -118, -120, -119,
-119, -117, -119, -118, -119, -117, -120, -116, -120, -115, -122, -75, 25, 37,
34, 34, 34, 35, 35, 35, 34, 35, 33, 36, 35, 34, 34, 35, 34, 34, 34, 35, 35, 35,
35, 35, 35, 34, 36, 35, 35, 34, 34, 34, 35, 35, 35, 35, 35, 36, 34, 36, 33, 39,
-47, -109, -88, -82, -67, -61, -50, -44, -35, -30, -23, -18, -14, -9, -4, -1, };