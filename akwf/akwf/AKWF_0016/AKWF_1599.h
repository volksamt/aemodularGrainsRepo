#define DATA_LENGTH 512
#define DATA AKWF_1599

const PROGMEM int8_t DATA[DATA_LENGTH] = {38, 44, 41, 43, 42, 44, 42, 44, 42,
44, 41, 44, 41, 44, 40, 45, 40, 47, 35, 65, 127, 115, 121, 119, 120, 120, 119,
120, 119, 119, 119, 120, 119, 120, 118, 119, 118, 119, 119, 119, 119, 119, 118,
120, 119, 120, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 118, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 120, 118, 120,
118, 119, 118, 120, 118, 120, 118, 120, 118, 119, 119, 118, 122, 54, 37, 45, 40,
44, 40, 44, 41, 43, 41, 43, 41, 43, 41, 43, 41, 42, 42, 42, 42, 41, 43, 43, 43,
43, 43, 41, 42, 42, 43, 42, 43, 41, 42, 42, 42, 42, 43, 42, 43, 42, 42, 43, 43,
42, 41, 42, 42, 42, 42, 43, 42, 42, 42, 42, 43, 43, 42, 42, 42, 42, 42, 42, 42,
42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 41, 42, 42, 42, 42, 42, 43, 42, 42,
43, 41, 42, 43, 43, 42, 42, 42, 42, 43, 42, 42, 42, 42, 42, 42, 42, 43, 43, 43,
42, 42, 42, 42, 42, 43, 43, 43, 43, 43, 42, 42, 43, 42, 42, 42, 42, 42, 43, 42,
42, 42, 42, 43, 43, 42, 43, 42, 42, 43, 42, 44, 40, 47, 14, -5, 3, -2, 1, 0, 1,
0, 1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 1, -1, 1, -1, 2, -2, 4, -16, -47, -41,
-44, -41, -43, -42, -43, -42, -42, -42, -42, -43, -42, -42, -42, -43, -41, -43,
-42, -42, -42, -43, -42, -43, -42, -42, -42, -43, -43, -42, -42, -42, -42, -42,
-42, -42, -42, -43, -43, -42, -42, -42, -43, -42, -43, -42, -43, -42, -43, -42,
-42, -43, -43, -42, -42, -43, -42, -42, -42, -43, -41, -42, -41, -42, -42, -43,
-42, -43, -43, -42, -41, -42, -42, -42, -43, -43, -43, -41, -42, -43, -42, -43,
-42, -42, -42, -42, -42, -42, -42, -42, -42, -43, -42, -42, -43, -42, -43, -42,
-42, -42, -42, -41, -42, -42, -42, -41, -43, -43, -42, -42, -42, -41, -42, -42,
-42, -41, -42, -42, -43, -42, -43, -42, -41, -42, -42, -43, -41, -44, -41, -44,
-40, -44, -39, -44, -39, -46, -36, -59, -124, -117, -119, -119, -119, -119,
-118, -119, -118, -119, -118, -119, -119, -120, -117, -119, -119, -120, -119,
-118, -119, -119, -118, -118, -120, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -120, -119, -119, -118, -120, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -120, -118, -120, -118, -119,
-118, -119, -118, -120, -118, -119, -118, -119, -120, -117, -121, -116, -125,
-60, -35, -47, -39, -45, -41, -45, -41, -45, -41, -44, -40, -43, -41, -44, -41,
-45, -41, -45, -36, };