#define DATA_LENGTH 512
#define DATA AKWF_1550

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 7, 8, 9, 9, 11, 12, 12,
12, 13, 14, 14, 15, 15, 16, 16, 15, 16, 17, 16, 18, 18, 17, 17, 17, 18, 18, 18,
18, 18, 18, 18, 19, 19, 18, 18, 18, 18, 18, 19, 19, 19, 19, 19, 19, 18, 19, 19,
19, 18, 19, 19, 19, 19, 19, 18, 20, 19, 18, 19, 19, 19, 18, 20, 19, 19, 19, 18,
18, 18, 18, 18, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 18, 19, 19, 19, 18, 18,
19, 18, 18, 19, 19, 18, 18, 19, 18, 18, 19, 19, 19, 19, 18, 19, 19, 18, 18, 19,
18, 19, 19, 18, 18, 18, 18, 18, 19, 18, 18, 19, 18, 19, 19, 18, 19, 19, 18, 19,
19, 18, 18, 18, 19, 18, 18, 18, 18, 18, 18, 19, 18, 19, 18, 19, 18, 18, 18, 19,
18, 18, 18, 18, 18, 17, 19, 17, 19, 17, 19, 16, 20, 14, 25, -20, -112, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -118, -120, -119, -119, -118, -119, -118, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -118, -118, -118, -118, -119, -118, -119, -118, -119,
-118, -119, -117, -120, -117, -120, -116, -122, -90, 5, 23, 18, 20, 19, 20, 18,
20, 18, 20, 19, 20, 19, 20, 18, 19, 19, 20, 19, 20, 19, 19, 19, 20, 20, 20, 19,
19, 19, 19, 20, 19, 19, 19, 19, 19, 20, 20, 20, 19, 19, 20, 19, 20, 19, 19, 19,
19, 20, 19, 19, 19, 19, 20, 19, 19, 19, 20, 20, 19, 19, 20, 20, 19, 19, 19, 19,
20, 19, 19, 19, 19, 20, 19, 19, 19, 19, 19, 19, 19, 20, 19, 18, 19, 19, 19, 19,
19, 19, 20, 20, 19, 20, 19, 20, 19, 20, 20, 19, 19, 20, 19, 20, 19, 19, 18, 20,
19, 20, 19, 20, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19,
19, 20, 18, 19, 19, 20, 19, 20, 19, 20, 18, 19, 19, 20, 19, 19, 19, 20, 16, -69,
-107, -88, -83, -70, -64, -54, -50, -42, -38, -31, -27, -23, -19, -16, -12, -9,
-7, -5, -3, -1, 2, 3, 5, 7, 7, 8, 10, 10, 11, 12, 12, 13, 14, 14, 14, 16, 15,
16, 17, 17, 17, 18, 17, 17, 17, 18, 19, 18, 18, 19, 19, 18, 18, 19, 19, 19, 19,
18, 18, 19, 19, 19, 19, 18, 18, 20, 19, 19, 19, 19, 20, 19, 19, 19, 19, 19, 19,
19, 19, 19, 19, 18, 19, 19, 19, 19, 19, 18, 19, 18, 19, 19, 19, 18, 19, 19, 19,
19, 19, 19, 19, 19, 19, 20, 19, 20, 19, 20, 19, 20, 19, 19, 18, 20, 19, 20, 18,
19, 19, 20, 19, 19, 19, 20, 18, 19, 10, -86, -107, -85, -82, -69, -63, -53, -49,
-41, -37, -31, -27, -22, -18, -15, -12, -9, -7, -4, -2, 0, };