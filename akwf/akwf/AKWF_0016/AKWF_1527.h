#define DATA_LENGTH 512
#define DATA AKWF_1527

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 13, 26, 36, 47, 56, 64, 72, 79, 86,
92, 95, 100, 103, 107, 109, 110, 112, 113, 114, 113, 113, 112, 111, 110, 109,
108, 105, 102, 102, 98, 95, 94, 91, 88, 86, 82, 79, 76, 73, 70, 67, 66, 61, 59,
57, 53, 51, 48, 46, 43, 40, 39, 35, 34, 31, 29, 27, 25, 23, 21, 19, 18, 16, 14,
12, 11, 10, 8, 7, 5, 5, 4, 2, 1, 0, -1, -1, -3, -4, -4, -5, -5, -5, -6, -6, -7,
-8, -8, -9, -10, -9, -9, -9, -10, -10, -11, -11, -10, -10, -10, -10, -11, -10,
-10, -9, -10, -10, -10, -9, -9, -9, -8, -8, -7, -7, -7, -5, -5, -4, -5, -3, -2,
-2, 0, 1, 1, 2, 3, 5, 6, 8, 9, 10, 12, 13, 15, 16, 18, 19, 22, 24, 25, 28, 30,
32, 35, 36, 39, 41, 43, 45, 47, 49, 51, 51, 53, 54, 54, 53, 53, 51, 48, 44, 39,
33, 26, 17, 7, -6, -18, -34, -51, -70, -87, -101, -110, -115, -118, -120, -119,
-118, -118, -117, -115, -114, -113, -112, -110, -109, -108, -107, -106, -105,
-106, -104, -103, -102, -101, -100, -99, -97, -97, -96, -95, -92, -81, -61, -30,
5, 40, 68, 86, 97, 103, 105, 107, 106, 107, 104, 104, 103, 103, 101, 99, 99, 98,
97, 97, 95, 94, 94, 93, 92, 91, 90, 88, 89, 87, 87, 86, 86, 85, 84, 83, 82, 81,
79, 80, 78, 72, 62, 50, 37, 24, 10, -4, -16, -27, -38, -48, -57, -66, -73, -80,
-86, -92, -96, -100, -105, -106, -109, -111, -112, -112, -114, -114, -112, -112,
-111, -110, -109, -106, -105, -103, -101, -98, -95, -93, -90, -87, -85, -82,
-79, -76, -73, -69, -68, -65, -62, -59, -57, -54, -51, -48, -45, -42, -40, -38,
-35, -33, -31, -28, -26, -24, -23, -20, -19, -17, -16, -13, -13, -11, -9, -8,
-7, -6, -4, -3, -2, -1, 0, 1, 2, 2, 3, 3, 4, 5, 6, 7, 8, 7, 8, 9, 9, 10, 9, 9,
10, 10, 10, 11, 11, 10, 11, 10, 10, 10, 10, 10, 10, 9, 10, 9, 9, 9, 8, 8, 8, 8,
7, 6, 6, 5, 5, 4, 3, 2, 2, 1, 0, -1, -2, -4, -5, -5, -7, -8, -10, -11, -13, -15,
-16, -19, -20, -22, -24, -26, -27, -30, -33, -34, -37, -39, -41, -43, -46, -48,
-50, -51, -51, -53, -53, -54, -53, -52, -50, -48, -43, -39, -33, -24, -17, -6,
6, 19, 35, 53, 72, 89, 103, 111, 116, 118, 119, 118, 117, 117, 116, 116, 114,
114, 111, 111, 109, 109, 107, 106, 105, 104, 104, 102, 102, 100, 99, 99, 98, 96,
96, 95, 92, 80, 58, 27, -9, -44, -70, -87, -97, -103, -105, -106, -106, -106,
-104, -103, -103, -103, -101, -99, -99, -98, -97, -97, -95, -95, -94, -93, -92,
-90, -90, -90, -89, -87, -87, -85, -85, -84, -83, -82, -81, -81, -80, -79, -76,
-70, -61, -49, -36, -22, -8, };