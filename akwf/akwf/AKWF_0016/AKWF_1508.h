#define DATA_LENGTH 512
#define DATA AKWF_1508

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 42, 39, 41, 39, 40, 38, 40, 39,
41, 39, 40, 40, 39, 40, 40, 39, 40, 40, 40, 40, 40, 39, 39, 40, 40, 41, 40, 40,
40, 40, 39, 40, 39, 39, 39, 40, 40, 41, 39, 40, 39, 40, 39, 39, 40, 40, 40, 39,
40, 40, 40, 39, 40, 40, 39, 39, 39, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40,
39, 39, 39, 39, 40, 40, 39, 40, 40, 39, 40, 40, 39, 40, 40, 40, 39, 39, 76, 81,
77, 81, 76, 112, 122, 118, 119, 118, 120, 119, 119, 119, 120, 119, 119, 120,
120, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 120, 119, 119, 119,
120, 119, 119, 119, 120, 119, 119, 120, 119, 119, 118, 120, 119, 120, 118, 120,
118, 121, 118, 121, 118, 121, 117, 122, 116, 121, 117, 120, 119, 119, 124, -56,
-90, -72, -85, -74, -84, -76, -83, -76, -82, -77, -82, -77, -82, -77, -81, -78,
-80, -78, -80, -78, -81, -78, -82, -74, -38, -41, -39, -40, -40, -41, -39, -40,
-39, -40, -40, -40, -40, -40, -40, -39, -40, -39, -40, -39, -40, -39, -40, -39,
-41, -39, -41, -40, -41, -39, -40, -40, -40, -41, -40, -40, -39, -42, -9, 3, -2,
1, -1, 1, -1, 1, -1, 0, -1, 0, 0, 0, -1, 1, 1, -1, 0, -1, 1, 0, 0, 0, 1, 1, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 1, -1, 1, -1, 2, -2, 2, -3, 11, 44,
38, 41, 39, 40, 39, 40, 39, 39, 40, 40, 40, 39, 40, 39, 41, 40, 40, 39, 41, 39,
40, 39, 40, 39, 41, 40, 40, 40, 39, 39, 40, 40, 39, 40, 39, 40, 39, 75, 81, 79,
80, 79, 80, 78, 81, 78, 81, 78, 80, 78, 82, 77, 82, 76, 83, 75, 84, 74, 87, 71,
94, 44, -128, -114, -121, -118, -118, -120, -118, -121, -118, -121, -118, -122,
-117, -121, -118, -121, -118, -121, -117, -121, -118, -120, -119, -119, -119,
-119, -118, -119, -120, -118, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -120, -118, -119, -118, -120, -120, -120, -119, -119, -119, -118,
-120, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -120, -119, -120, -118, -120, -118, -119, -117, -121, -109, -75,
-82, -77, -83, -74, -38, -40, -40, -40, -39, -40, -40, -39, -40, -40, -41, -39,
-39, -39, -40, -39, -41, -39, -40, -40, -39, -40, -39, -39, -40, -39, -40, -40,
-40, -39, -40, -39, -39, -39, -39, -39, -39, -39, -39, -40, -40, -39, -39, -40,
-40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -39, -40, -39, -40, -39,
-40, -40, -40, -39, -39, -39, -39, -40, -39, -40, -39, -40, -39, -40, -40, -40,
-39, -40, -38, -40, -40, -40, -39, -41, -38, -42, -34, };