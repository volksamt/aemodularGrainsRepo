#define DATA_LENGTH 512
#define DATA AKWF_1583

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 71, 74, 76, 80, 85, 92, 100, 108,
120, 97, 29, 11, 6, 0, -8, -16, -24, -29, -34, -37, -37, -37, -35, -34, -34,
-34, -34, -37, -40, -44, -47, -51, -53, -56, -56, -57, -57, -56, -55, -53, -52,
-53, -54, -54, -56, -57, -59, -59, -60, -60, -59, -58, -58, -56, -55, -56, -55,
-54, -53, -54, -54, -53, -54, -53, -53, -52, -51, -50, -49, -48, -47, -47, -45,
-45, -44, -44, -44, -43, -43, -42, -41, -40, -39, -38, -37, -36, -36, -35, -33,
-33, -33, -32, -31, -31, -30, -30, -28, -28, -27, -26, -26, -24, -24, -22, -22,
-22, -20, -20, -19, -19, -19, -18, -16, -16, -15, -14, -14, -12, -13, -12, -11,
-10, -9, -9, -8, -9, -8, -8, -7, -6, -5, -5, -5, -4, -2, -2, -1, -2, -1, -1, 0,
1, 2, 3, 3, 3, 3, 4, 4, 4, 6, 6, 6, 7, 8, 7, 7, 8, 9, 9, 9, 9, 10, 11, 11, 12,
12, 12, 12, 13, 13, 14, 15, 14, 15, 14, 15, 15, 15, 16, 17, 16, 17, 17, 18, 18,
18, 17, 18, 19, 19, 19, 20, 19, 20, 20, 21, 21, 21, 21, 21, 22, 21, 21, 21, 22,
22, 22, 23, 22, 22, 22, 23, 23, 23, 23, 23, 23, 24, 23, 24, 24, 24, 24, 23, 24,
25, 24, 25, 24, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 26, 25, 25, 25,
26, 25, 26, 24, 24, 25, 25, 26, 25, 25, 25, 25, 26, 24, 25, 25, 25, 25, 25, 25,
24, 25, 25, 25, 25, 25, 25, 24, 24, 24, 24, 24, 24, 24, 24, 23, 24, 24, 23, 23,
24, 24, 22, 24, 23, 22, 23, 23, 22, 22, 22, 22, 22, 22, 21, 21, 22, 22, 21, 22,
21, 21, 20, 20, 21, 20, 20, 20, 20, 19, 19, 19, 19, 20, 19, 18, 18, 19, 18, 18,
18, 18, 17, 18, 17, 18, 16, 17, 16, 16, 17, 16, 16, 15, 15, 15, 15, 15, 14, 14,
14, 14, 14, 14, 13, 14, 13, 13, 13, 12, 12, 12, 12, 12, 11, 12, 12, 11, 11, 11,
11, 11, 10, 9, 10, 9, 9, 9, 8, 8, 9, 8, 8, 7, 7, 7, 7, 7, 6, 7, 6, 5, 6, 6, 5,
6, 4, 4, 4, 4, 4, 3, 3, 4, 3, 2, 2, 2, 2, 2, 2, 1, 1, 1, 1, 1, 1, 0, 0, -1, -1,
-1, -1, -2, -1, -1, -2, -2, -2, -3, -3, -4, -3, -4, -5, -4, -5, -5, -5, -5, -6,
-6, -5, -6, -7, -7, -7, -7, -8, -8, -8, -8, -9, -9, -9, -9, -10, -9, -10, -10,
-11, -11, -11, -11, -12, -11, -12, -13, -12, -12, -14, -14, -14, -14, -14, -15,
-15, -15, -15, -15, -16, -16, -16, -16, -16, -17, -17, -17, -18, -17, -18, -18,
-19, -19, -19, -20, -20, -20, -20, -20, -21, -21, -21, -22, -21, -22, -22, -23,
-21, -23, -23, -23, -22, -25, -21, };