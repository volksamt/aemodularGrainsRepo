#define DATA_LENGTH 512
#define DATA AKWF_1516

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 22, 18, 24, 28, 28, 27, 27, 28,
28, 27, 28, 27, 27, 28, 27, 28, 27, 28, 27, 28, 27, 27, 27, 27, 28, 27, 28, 27,
28, 27, 27, 27, 28, 36, 43, 36, 52, 73, 68, 71, 71, 72, 72, 71, 72, 72, 71, 71,
71, 72, 72, 72, 72, 72, 72, 71, 72, 72, 72, 72, 71, 72, 72, 72, 72, 71, 71, 72,
71, 72, 71, 71, 71, 72, 70, 69, 69, 70, 69, 69, 70, 69, 69, 69, 69, 69, 69, 70,
70, 69, 70, 69, 70, 70, 70, 70, 69, 69, 69, 69, 69, 70, 69, 70, 70, 70, 69, 69,
75, 81, 75, 90, 115, 110, 111, 118, 120, 118, 119, 119, 120, 119, 119, 120, 119,
119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119,
120, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
118, 119, 119, 119, 119, 118, 118, 119, 119, 120, 119, 119, 120, 119, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 120, 119, 120, 113, 94, 99, 97, 73, 67, 71, 69, 70, 69, 70, 70,
68, 74, 35, 11, 23, 11, 0, -1, 0, -1, 1, -1, 1, -1, 0, -1, 1, 0, 1, 0, 0, 0, 1,
-1, 1, 0, -12, -22, -11, -38, -75, -67, -70, -69, -69, -70, -69, -71, -67, -75,
-98, -98, -95, -114, -120, -119, -120, -120, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -118, -119, -119, -119, -120, -119, -120, -119, -119, -119, -118, -120,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -120, -119, -119, -118, -120, -120, -119, -119, -119,
-119, -118, -118, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -118, -119, -119, -119, -118, -119, -120, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -112, -110,
-114, -88, -76, -82, -74, -69, -69, -70, -68, -69, -70, -70, -69, -69, -70, -70,
-69, -70, -69, -69, -69, -69, -69, -69, -69, -70, -69, -70, -69, -69, -70, -69,
-69, -69, -70, -69, -70, -70, -69, -72, -71, -72, -71, -72, -72, -71, -72, -72,
-72, -71, -72, -72, -71, -72, -72, -72, -72, -72, -71, -72, -72, -71, -73, -72,
-71, -72, -72, -71, -72, -71, -71, -72, -71, -70, -68, -72, -50, -36, -43, -36,
-28, -27, -27, -28, -28, -28, -28, -27, -28, -27, -28, -27, -27, -28, -28, -28,
-27, -28, -27, -27, -27, -27, -27, -27, -28, -28, -28, -27, -28, -28, -23, -18,
-22, -16, };