#define DATA_LENGTH 512
#define DATA AKWF_1520

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 16, 18, 21, 24, 27, 28, 33, 35,
37, 40, 43, 45, 48, 50, 53, 56, 58, 60, 63, 66, 69, 72, 74, 77, 80, 82, 85, 87,
90, 93, 95, 97, 100, 103, 105, 108, 111, 113, 117, 119, 117, 114, 111, 109, 106,
103, 101, 99, 97, 93, 90, 89, 86, 83, 80, 77, 75, 72, 69, 67, 66, 62, 60, 57,
54, 52, 49, 46, 43, 42, 39, 36, 33, 32, 27, 26, 23, 21, 18, 15, 13, 10, 7, 5, 2,
1, 2, 2, 1, 1, 2, 1, 2, 1, 1, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2,
1, 2, 2, 2, 2, 1, 2, 1, 2, 1, 2, 2, 3, 5, 8, 10, 13, 15, 18, 21, 23, 26, 29, 30,
33, 36, 38, 41, 44, 46, 49, 51, 53, 57, 59, 61, 64, 67, 69, 72, 74, 76, 79, 82,
85, 87, 89, 91, 95, 96, 99, 102, 105, 107, 109, 112, 115, 116, 114, 111, 109,
105, 102, 101, 98, 95, 93, 91, 87, 85, 82, 79, 77, 74, 72, 69, 67, 65, 62, 60,
57, 54, 51, 49, 47, 44, 41, 38, 36, 33, 31, 29, 24, 26, 7, -2, 2, -1, 1, 0, 0,
0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
0, 0, -1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, 1, 1, -1, 1, 0, 0, -1, 0, -1, 0, -1, 1, 0, 0, 0, 0, 1, 0, 0, 1, 0, -1, 1, -1,
0, -1, -1, 0, 0, 0, -1, 0, 0, 1, -1, 0, -1, 2, -8, -25, -24, -29, -30, -34, -36,
-38, -41, -44, -46, -49, -52, -54, -57, -58, -62, -65, -67, -70, -73, -74, -77,
-80, -82, -84, -88, -90, -92, -95, -98, -101, -103, -105, -108, -111, -113,
-117, -115, -111, -109, -107, -105, -102, -99, -97, -93, -92, -89, -86, -84,
-82, -79, -77, -73, -71, -68, -67, -63, -62, -58, -56, -53, -52, -49, -45, -44,
-41, -38, -35, -33, -30, -28, -26, -22, -21, -18, -15, -13, -10, -8, -6, -2, -1,
-1, -1, -1, -2, -1, -1, -2, -1, -2, -1, -2, -2, -1, -1, -2, -1, -1, -1, -1, -1,
-1, -1, -2, -1, -1, -2, -1, -2, -1, -2, -1, -1, -2, -1, -1, -2, -2, -1, -2, -6,
-7, -10, -13, -15, -18, -21, -23, -26, -28, -30, -34, -36, -39, -42, -44, -48,
-50, -53, -55, -57, -60, -63, -65, -68, -71, -72, -76, -77, -81, -84, -87, -89,
-91, -93, -96, -98, -101, -103, -107, -109, -112, -114, -117, -119, -116, -113,
-111, -108, -105, -102, -101, -98, -94, -92, -90, -87, -84, -82, -79, -77, -74,
-70, -69, -66, -63, -60, -58, -56, -53, -51, -47, -45, -43, -40, -38, -34, -32,
-29, -27, -24, -21, -18, -16, -12, };