#define DATA_LENGTH 512
#define DATA AKWF_1525

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 10, 11, 15, 20, 19, 21, 37, 59, 68,
68, 70, 73, 74, 77, 80, 82, 83, 83, 84, 84, 84, 84, 86, 87, 87, 90, 91, 92, 91,
92, 92, 92, 91, 93, 93, 94, 95, 95, 96, 97, 97, 97, 97, 98, 99, 99, 99, 101,
102, 102, 103, 105, 104, 105, 106, 107, 107, 109, 110, 110, 111, 112, 112, 114,
114, 114, 115, 116, 117, 117, 118, 117, 118, 118, 118, 119, 119, 119, 119, 119,
119, 119, 119, 118, 118, 118, 118, 115, 106, 98, 96, 97, 97, 97, 97, 97, 94, 93,
91, 88, 85, 83, 84, 82, 81, 81, 81, 80, 79, 78, 76, 75, 74, 73, 73, 73, 73, 73,
73, 73, 72, 72, 71, 71, 71, 70, 71, 70, 70, 71, 70, 70, 71, 69, 70, 70, 69, 69,
67, 68, 68, 67, 66, 65, 64, 64, 63, 62, 61, 60, 59, 58, 58, 57, 56, 54, 54, 53,
52, 51, 50, 48, 47, 47, 46, 45, 44, 43, 41, 41, 41, 40, 39, 38, 38, 38, 37, 37,
36, 35, 36, 35, 35, 35, 34, 34, 34, 34, 34, 33, 34, 34, 33, 33, 34, 32, 33, 32,
32, 32, 32, 32, 31, 31, 30, 29, 29, 28, 28, 28, 26, 26, 26, 25, 24, 23, 23, 22,
21, 20, 19, 18, 17, 16, 15, 15, 13, 12, 12, 11, 11, 10, 9, 8, 7, 7, 6, 6, 4, 4,
4, 4, 3, 3, 3, 1, 1, 1, 1, 1, 0, 1, 1, 1, 0, 0, 0, 0, -1, 0, -1, -1, -1, -2, -2,
-2, -3, -3, -3, -3, -4, -4, -5, -6, -7, -8, -9, -9, -10, -11, -11, -12, -13,
-14, -15, -15, -17, -17, -18, -20, -20, -21, -22, -22, -23, -24, -25, -25, -27,
-27, -28, -28, -28, -29, -29, -31, -31, -31, -32, -32, -32, -32, -32, -32, -33,
-32, -33, -32, -34, -34, -33, -34, -34, -34, -34, -34, -34, -35, -35, -35, -36,
-36, -37, -37, -38, -38, -38, -39, -40, -40, -41, -43, -44, -44, -45, -46, -46,
-48, -49, -50, -50, -52, -53, -54, -55, -56, -57, -58, -58, -59, -60, -61, -62,
-64, -65, -65, -66, -66, -67, -67, -68, -69, -68, -68, -68, -69, -70, -70, -71,
-71, -71, -71, -71, -71, -71, -70, -70, -71, -72, -73, -73, -73, -73, -74, -72,
-74, -73, -74, -75, -76, -78, -79, -79, -81, -81, -81, -82, -83, -84, -85, -89,
-90, -92, -95, -98, -97, -97, -97, -97, -97, -99, -108, -115, -118, -117, -118,
-119, -119, -119, -119, -120, -119, -119, -118, -118, -119, -119, -118, -118,
-117, -117, -116, -116, -114, -114, -114, -112, -112, -112, -110, -111, -109,
-108, -108, -106, -106, -105, -105, -104, -104, -103, -101, -101, -101, -100,
-98, -97, -98, -97, -97, -96, -97, -96, -95, -93, -93, -92, -92, -92, -91, -91,
-91, -90, -91, -89, -88, -86, -86, -84, -84, -85, -84, -84, -82, -81, -79, -76,
-74, -73, -70, -68, -68, -58, -35, -21, -21, -21, -15, -10, -10, -4, };