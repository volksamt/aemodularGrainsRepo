#define DATA_LENGTH 512
#define DATA AKWF_1539

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 2, 2, 3, 4, 4, 5, 5, 6, 6,
6, 6, 7, 7, 8, 8, 9, 9, 10, 10, 10, 11, 11, 13, 12, 14, 14, 13, 14, 15, 15, 16,
16, 16, 17, 17, 18, 18, 19, 19, 20, 19, 20, 21, 21, 22, 23, 23, 23, 24, 24, 25,
25, 26, 26, 27, 28, 28, 28, 28, 29, 30, 30, 30, 31, 31, 31, 32, 33, 33, 33, 33,
33, 35, 35, 36, 36, 36, 37, 38, 38, 39, 38, 40, 39, 40, 40, 41, 41, 41, 42, 43,
43, 43, 44, 44, 45, 45, 46, 46, 47, 47, 48, 48, 49, 49, 49, 50, 50, 50, 51, 51,
51, 53, 53, 54, 54, 54, 55, 55, 55, 56, 56, 57, 57, 59, 56, 60, 57, 61, 58, 62,
58, 63, 59, 64, 60, 65, 61, 64, 64, 63, 66, 62, 72, 52, 110, -7, -74, -48, -67,
-51, -63, -53, -61, -53, -58, -53, -56, -54, -55, -53, -53, -52, -51, -51, -51,
-52, -49, -49, -49, -49, -47, -49, -47, -48, -46, -46, -45, -45, -45, -45, -43,
-44, -42, -42, -42, -41, -41, -40, -41, -39, -39, -38, -38, -38, -37, -37, -37,
-35, -36, -35, -35, -34, -34, -33, -33, -33, -31, -31, -31, -30, -31, -29, -29,
-28, -28, -27, -27, -26, -26, -26, -25, -24, -24, -24, -24, -22, -22, -22, -22,
-21, -21, -20, -20, -20, -19, -18, -18, -18, -17, -16, -16, -16, -16, -14, -14,
-14, -14, -14, -12, -12, -12, -11, -10, -10, -9, -9, -8, -8, -7, -8, -8, -7, -6,
-5, -5, -5, -3, -3, -4, -3, -3, -1, -2, -1, 0, 0, 0, 2, 2, 2, 3, 2, 4, 3, 3, 4,
5, 6, 6, 7, 7, 7, 8, 9, 9, 9, 9, 10, 10, 11, 11, 11, 12, 13, 12, 13, 14, 14, 14,
15, 16, 16, 16, 17, 17, 18, 18, 18, 19, 20, 20, 21, 21, 22, 21, 22, 23, 24, 23,
24, 25, 25, 26, 26, 27, 27, 28, 28, 29, 29, 30, 30, 31, 30, 31, 32, 32, 31, 34,
32, 34, 34, 35, 35, 36, 36, 36, 37, 37, 38, 37, 40, 38, 41, 39, 42, 39, 44, 38,
45, 39, 47, 39, 48, 40, 50, 40, 47, 89, -52, -60, -55, -60, -53, -60, -53, -58,
-52, -57, -51, -56, -51, -55, -50, -52, -50, -51, -50, -50, -48, -48, -48, -48,
-48, -47, -47, -46, -45, -45, -45, -44, -44, -43, -43, -42, -42, -41, -41, -40,
-40, -39, -39, -38, -38, -38, -37, -37, -36, -36, -35, -35, -34, -34, -34, -33,
-32, -33, -32, -31, -31, -30, -30, -29, -29, -29, -27, -27, -26, -27, -27, -26,
-25, -24, -24, -23, -24, -23, -22, -22, -21, -20, -21, -20, -19, -19, -19, -18,
-18, -17, -17, -17, -16, -16, -15, -15, -14, -14, -13, -13, -13, -13, -11, -12,
-10, -10, -10, -10, -9, -8, -8, -7, -8, -7, -7, -6, -5, -5, -4, -4, -3, -2, -2,
-2, -1, -1, -1, 0, };