#define DATA_LENGTH 512
#define DATA AKWF_1548

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 5, 7, 8, 9, 10, 11, 11, 12,
12, 13, 14, 15, 15, 15, 16, 16, 16, 17, 16, 18, 16, 17, 18, 17, 18, 17, 18, 18,
18, 19, 18, 18, 18, 18, 18, 18, 19, 18, 18, 18, 18, 18, 19, 19, 19, 18, 20, 19,
19, 18, 20, 19, 18, 19, 19, 18, 18, 18, 19, 18, 18, 19, 18, 18, 19, 19, 18, 19,
17, 20, 16, 22, -39, -109, -88, -81, -71, -63, -56, -49, -42, -36, -31, -27,
-24, -18, -16, -12, -10, -6, -5, -3, -2, 1, 3, 5, 5, 7, 8, 9, 9, 10, 11, 12, 13,
13, 13, 14, 15, 15, 15, 16, 15, 16, 17, 17, 17, 17, 17, 17, 18, 17, 18, 18, 18,
18, 17, 18, 19, 19, 19, 18, 18, 18, 19, 18, 19, 18, 18, 19, 19, 19, 19, 19, 18,
19, 18, 19, 18, 18, 18, 19, 18, 19, 18, 19, 18, 18, 19, 18, 18, 18, 18, 18, 19,
19, 19, 19, 18, 19, 19, 18, 18, 18, 18, 18, 18, 19, 19, 18, 19, 19, 18, 18, 19,
18, 19, 18, 19, 18, 18, 18, 19, 18, 18, 19, 18, 18, 18, 18, 18, 17, 18, 18, 18,
18, 18, 18, 19, 18, 18, 18, 19, 18, 18, 18, 18, 18, 18, 18, 18, 18, 19, 18, 18,
18, 17, 18, 18, 18, 18, 18, 17, 19, 17, 18, 17, 18, 18, 18, 18, 18, 18, 18, 19,
18, 18, 17, 19, 18, 19, 16, 20, 15, 20, 14, 21, 13, 27, -30, -127, -115, -121,
-118, -120, -119, -119, -119, -118, -120, -118, -119, -118, -120, -119, -119,
-119, -119, -118, -119, -119, -120, -119, -119, -118, -119, -118, -119, -118,
-119, -118, -119, -118, -119, -118, -118, -118, -119, -118, -119, -118, -118,
-118, -117, -118, -117, -120, -117, -114, -32, 26, 16, 20, 19, 20, 18, 20, 19,
19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 20, 19, 19, 19, 19, 19, 19,
19, 19, 19, 20, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 20, 19, 19, 19, 19, 19,
20, 19, 20, 19, 19, 20, 19, 20, 20, 19, 19, 18, 19, 19, 19, 19, 19, 19, 20, 19,
19, 19, 19, 19, 19, 19, 19, 19, 19, 20, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19,
19, 19, 18, 19, 19, 20, 19, 19, 20, 19, 19, 19, 19, 18, 19, 19, 19, 19, 18, 19,
19, 18, 19, 19, 19, 19, 19, 18, 19, 19, 19, 19, 19, 19, 19, 19, 20, 19, 20, 19,
19, 19, 19, 19, 19, 19, 19, 18, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 18, 19,
19, 19, 18, 18, 19, 19, 19, 19, 19, 18, 19, 18, 18, 18, 19, 18, 18, 18, 20, 18,
19, 18, 19, 18, 18, 19, 17, 20, 17, 21, -79, -112, -83, -84, -66, -65, -52, -50,
-41, -37, -31, -28, -22, -18, -16, -12, -10, -7, -5, -2, 0, };