#define DATA_LENGTH 512
#define DATA AKWF_1576

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 24, 23, 23, 22, 22, 22, 22, 21,
20, 20, 19, 19, 19, 19, 18, 17, 18, 17, 17, 17, 16, 15, 16, 16, 16, 15, 15, 15,
14, 13, 13, 14, 12, 12, 12, 14, 43, 96, 117, 119, 117, 116, 115, 115, 113, 112,
111, 110, 110, 108, 107, 106, 106, 104, 104, 104, 102, 102, 101, 100, 99, 98,
97, 97, 95, 95, 93, 93, 91, 91, 90, 90, 89, 88, 87, 86, 86, 85, 84, 83, 82, 81,
81, 80, 79, 79, 79, 77, 77, 75, 75, 74, 73, 72, 72, 71, 71, 69, 69, 68, 68, 56,
18, -21, -31, -30, -30, -30, -31, -31, -33, 28, 58, 47, 52, 48, 51, 49, 50, 49,
50, 49, 49, 49, 49, 48, 48, 48, 48, 48, 47, 48, 48, 47, 47, 47, 47, 47, 46, 47,
46, 46, 46, 46, 45, 45, 45, 46, 45, 46, 45, 45, 45, 45, 45, 45, 45, 44, 44, 44,
44, 44, 43, 43, 44, 43, 43, 43, 43, 43, 42, 43, 42, 42, 43, 43, 43, 42, 42, 41,
41, 41, 41, 41, 42, 41, 42, 41, 41, 40, 41, 41, 41, 40, 40, 40, 41, 40, 40, 40,
40, 40, 39, 40, 39, 40, 39, 40, 39, 39, 39, 39, 39, 39, 38, 39, 39, 38, 38, 39,
38, 38, 38, 38, 38, 37, 38, 37, 38, 37, 36, 37, 37, 37, 37, 37, 37, 36, 36, 37,
36, 37, 37, 37, 37, 35, 37, 35, 36, 36, 36, 35, 35, 35, 35, 36, 35, 36, 35, 35,
35, 35, 34, 34, 35, 34, 34, 35, 34, 34, 34, 34, 34, 34, 34, 35, 34, 34, 33, 15,
-30, -69, -75, -73, -73, -72, -72, -72, -71, -69, -70, -69, -68, -68, -68, -67,
-66, -66, -65, -65, -64, -64, -63, -63, -62, -61, -61, -60, -59, -60, -58, -58,
-59, -57, -56, -56, -55, -56, -55, -54, -54, -53, -53, -52, -52, -51, -51, -50,
-50, -49, -49, -48, -48, -47, -47, -47, -46, -45, -46, -45, -45, -44, -43, -42,
-42, -42, -42, -41, -41, -40, -40, -40, -39, -38, -39, -38, -37, -37, -37, -37,
-35, -35, -35, -34, -34, -33, -33, -33, -32, -32, -32, -31, -31, -30, -30, -30,
-29, -29, -28, -28, -28, -27, -27, -27, -26, -25, -26, -26, -25, -25, -23, -24,
-22, -22, -23, -23, -22, -22, -21, -22, -21, -21, -20, -19, -19, -20, -18, -18,
-18, -17, -17, -16, -16, -16, -16, -15, -16, -14, -16, -7, -39, -96, -95, -94,
-94, -94, -94, -93, -93, -92, -92, -91, -92, -92, -91, -90, -91, -90, -89, -90,
-89, -89, -89, -88, -88, -88, -88, -87, -88, -87, -86, -87, -86, -85, -86, -85,
-85, -84, -84, -85, -84, -83, -83, -83, -82, -83, -82, -81, -81, -82, -82, -80,
-80, -80, -81, -80, -80, -79, -79, -79, -79, -78, -78, -79, -78, -78, -77, -76,
-77, -77, -76, -76, -76, -76, -76, -75, -75, -75, -74, -74, -74, -73, -73, -73,
-73, -72, -73, -72, -72, -55, -15, };