#define DATA_LENGTH 512
#define DATA AKWF_1518

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 32, 82, 79, 85, 87, 90, 92, 93, 96,
97, 98, 99, 102, 103, 103, 105, 106, 106, 108, 109, 111, 111, 113, 113, 113,
114, 115, 116, 116, 116, 117, 116, 116, 118, 118, 119, 119, 119, 119, 119, 119,
119, 119, 120, 118, 119, 118, 117, 117, 117, 114, 115, 112, 112, 98, 87, 90, 89,
90, 90, 91, 90, 92, 92, 92, 93, 94, 95, 99, 100, 100, 100, 99, 100, 100, 100,
100, 100, 100, 102, 101, 101, 102, 102, 102, 102, 102, 103, 102, 102, 102, 102,
102, 102, 102, 102, 102, 101, 103, 102, 104, 103, 105, 102, 106, 97, 77, 76, 73,
71, 70, 67, 66, 65, 65, 64, 62, 62, 63, 60, 61, 60, 59, 58, 58, 57, 56, 57, 56,
55, 54, 55, 53, 54, 53, 53, 52, 52, 52, 52, 51, 51, 51, 50, 50, 50, 49, 50, 49,
49, 48, 48, 47, 48, 48, 47, 46, 47, 47, 45, 46, 46, 45, 45, 45, 44, 44, 45, 44,
44, 43, 44, 43, 43, 43, 43, 43, 43, 42, 42, 42, 42, 42, 41, 41, 42, 41, 41, 41,
41, 40, 40, 40, 39, 40, 39, 40, 40, 39, 39, 40, 39, 39, 39, 39, 39, 38, 38, 38,
39, 38, 39, 31, 25, 25, 23, 23, 22, 22, 21, 20, 19, 19, 19, 18, 18, 17, 16, 16,
15, 15, 14, 14, 12, 11, 10, 3, 2, 2, 2, 2, 2, 1, 2, 2, 1, 1, 1, 1, 0, 1, 1, 1,
1, 0, 0, 0, -1, -1, 0, 0, 0, -1, -1, -1, -1, -1, -2, -2, -2, -2, -2, -1, -4,
-11, -11, -12, -13, -15, -14, -15, -16, -16, -17, -18, -18, -18, -19, -19, -21,
-21, -21, -22, -23, -24, -25, -25, -32, -39, -36, -38, -38, -38, -38, -39, -39,
-39, -38, -40, -40, -39, -39, -40, -40, -39, -40, -40, -40, -40, -40, -41, -40,
-41, -42, -41, -42, -41, -42, -42, -42, -42, -43, -42, -42, -43, -43, -44, -44,
-44, -44, -44, -44, -45, -45, -45, -45, -45, -45, -46, -46, -46, -46, -46, -46,
-47, -47, -47, -48, -48, -49, -48, -48, -49, -48, -50, -51, -50, -51, -52, -51,
-51, -52, -53, -52, -53, -52, -54, -54, -55, -55, -55, -56, -56, -57, -58, -58,
-58, -60, -60, -61, -60, -61, -62, -63, -64, -66, -66, -67, -68, -69, -71, -73,
-75, -78, -98, -105, -102, -104, -102, -104, -103, -102, -102, -103, -102, -102,
-103, -103, -102, -103, -101, -101, -102, -102, -102, -101, -102, -101, -102,
-100, -101, -102, -101, -101, -101, -100, -100, -100, -100, -99, -99, -99, -95,
-94, -94, -92, -92, -91, -91, -90, -89, -90, -88, -90, -86, -99, -112, -112,
-116, -115, -117, -117, -117, -118, -119, -118, -119, -119, -119, -119, -120,
-119, -119, -118, -118, -117, -119, -117, -117, -117, -116, -115, -115, -114,
-113, -113, -113, -112, -111, -110, -109, -108, -106, -106, -104, -104, -102,
-101, -99, -98, -96, -96, -94, -92, -90, -86, -85, -81, -80, -28, -1, };