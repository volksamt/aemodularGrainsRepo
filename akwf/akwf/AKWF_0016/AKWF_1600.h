#define DATA_LENGTH 512
#define DATA AKWF_1600

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 26, 43, 59, 74, 86, 96, 104, 110,
112, 114, 114, 115, 115, 114, 112, 111, 111, 109, 107, 105, 102, 99, 95, 92, 90,
87, 84, 83, 82, 82, 82, 83, 85, 85, 86, 88, 88, 87, 85, 82, 79, 74, 70, 65, 61,
57, 54, 50, 46, 43, 41, 37, 33, 29, 25, 22, 20, 19, 20, 22, 27, 32, 39, 47, 55,
63, 70, 74, 78, 79, 79, 78, 76, 72, 68, 65, 61, 57, 54, 49, 44, 39, 34, 29, 23,
17, 12, 8, 6, 3, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, -1, -4, -7, -11, -14, -20, -26,
-31, -36, -40, -44, -47, -51, -53, -57, -58, -61, -63, -62, -61, -57, -51, -43,
-33, -20, -5, 10, 26, 42, 57, 71, 83, 93, 101, 108, 114, 116, 117, 119, 119,
120, 118, 119, 118, 116, 113, 112, 109, 105, 100, 96, 92, 89, 87, 86, 86, 86,
86, 88, 89, 90, 91, 92, 90, 89, 87, 83, 80, 77, 73, 68, 64, 60, 57, 52, 49, 44,
39, 33, 29, 23, 18, 14, 11, 10, 10, 11, 15, 19, 25, 32, 38, 45, 50, 57, 61, 63,
65, 67, 65, 64, 61, 57, 54, 51, 46, 43, 41, 38, 34, 31, 26, 21, 16, 10, 6, 1,
-3, -5, -6, -5, -4, 0, 1, 4, 5, 6, 5, 2, -2, -6, -11, -15, -21, -27, -31, -34,
-38, -41, -44, -47, -51, -54, -57, -61, -63, -63, -63, -60, -56, -49, -40, -30,
-18, -6, 7, 20, 30, 41, 50, 57, 61, 64, 64, 63, 60, 57, 53, 51, 46, 43, 40, 37,
35, 31, 26, 22, 16, 10, 6, 1, -3, -5, -6, -5, -3, -1, 0, 4, 6, 6, 5, 2, -1, -6,
-11, -17, -22, -27, -30, -34, -38, -40, -44, -46, -50, -54, -57, -61, -64, -66,
-66, -65, -64, -61, -56, -51, -44, -38, -31, -25, -19, -14, -11, -9, -10, -11,
-14, -18, -23, -29, -34, -39, -45, -48, -53, -57, -61, -65, -69, -72, -77, -80,
-84, -86, -89, -90, -91, -91, -89, -89, -88, -86, -86, -86, -86, -88, -90, -94,
-97, -101, -105, -109, -112, -114, -115, -117, -118, -118, -119, -119, -119,
-118, -116, -113, -108, -102, -92, -82, -70, -55, -40, -25, -9, 6, 21, 34, 44,
52, 58, 60, 62, 62, 60, 58, 56, 53, 50, 47, 43, 39, 35, 31, 26, 20, 15, 10, 7,
3, 2, 1, 0, 0, 0, -1, -1, -1, 0, 0, -2, -4, -6, -9, -13, -18, -23, -29, -34,
-39, -44, -50, -53, -57, -61, -65, -69, -72, -76, -78, -80, -80, -78, -74, -69,
-62, -54, -47, -39, -31, -26, -21, -20, -19, -20, -22, -25, -30, -33, -37, -42,
-44, -48, -50, -54, -57, -61, -66, -70, -75, -78, -82, -85, -87, -88, -88, -88,
-86, -84, -83, -83, -82, -82, -84, -84, -87, -90, -92, -96, -99, -102, -105,
-107, -109, -110, -112, -112, -114, -114, -114, -115, -114, -113, -109, -103,
-96, -85, -72, -58, -42, -25, -7, };