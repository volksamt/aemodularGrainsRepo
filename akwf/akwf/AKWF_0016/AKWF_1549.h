#define DATA_LENGTH 512
#define DATA AKWF_1549

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 3, 5, 7, 8, 9, 10, 12, 11, 12,
14, 13, 14, 15, 15, 15, 16, 16, 17, 16, 16, 17, 18, 17, 18, 18, 18, 19, 18, 19,
18, 19, 18, 19, 18, 18, 19, 19, 18, 18, 19, 19, 20, 19, 19, 19, 19, 19, 18, 18,
19, 20, 19, 19, 19, 19, 20, 19, 19, 19, 19, 19, 20, 19, 19, 19, 20, 20, 19, 19,
19, 19, 18, 20, 18, 20, 18, 21, 18, 20, 18, 21, 17, 22, 15, 26, -26, -112, -94,
-86, -75, -67, -60, -51, -46, -39, -34, -29, -25, -21, -19, -14, -12, -8, -6,
-3, -2, 2, 2, 4, 5, 6, 8, 9, 10, 10, 12, 12, 13, 13, 13, 14, 14, 15, 15, 16, 16,
16, 16, 17, 17, 18, 18, 17, 18, 18, 18, 18, 18, 18, 18, 19, 18, 18, 18, 19, 19,
19, 18, 19, 19, 18, 19, 19, 19, 19, 18, 19, 19, 19, 19, 19, 18, 19, 19, 18, 19,
18, 20, 19, 18, 19, 18, 19, 18, 19, 19, 19, 19, 19, 19, 19, 18, 19, 19, 18, 19,
19, 18, 18, 19, 19, 19, 18, 18, 19, 19, 19, 18, 19, 18, 19, 18, 18, 19, 19, 20,
19, 19, 19, 19, 19, 19, 19, 18, 19, 19, 19, 19, 19, 19, 18, 19, 18, 19, 18, 18,
18, 19, 18, 19, 18, 18, 19, 18, 19, 18, 18, 18, 19, 18, 19, 19, 18, 18, 18, 18,
19, 18, 18, 19, 18, 18, 18, 18, 18, 18, 18, 19, 18, 19, 18, 19, 18, 19, 17, 19,
18, 20, 17, 20, 17, 21, 8, -89, -123, -116, -121, -118, -120, -119, -120, -118,
-120, -118, -120, -119, -119, -119, -119, -119, -119, -118, -120, -118, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -118, -118,
-118, -119, -118, -119, -117, -119, -119, -119, -118, -119, -118, -118, -117,
-118, -112, -22, 26, 17, 22, 18, 20, 18, 21, 19, 21, 19, 20, 20, 20, 20, 19, 20,
20, 20, 19, 19, 19, 20, 19, 20, 19, 20, 20, 20, 20, 21, 19, 19, 19, 19, 19, 20,
20, 19, 20, 20, 20, 20, 19, 20, 20, 20, 20, 19, 19, 20, 19, 20, 19, 20, 20, 19,
20, 19, 20, 20, 20, 20, 20, 19, 20, 19, 20, 19, 20, 20, 20, 19, 20, 20, 19, 20,
19, 20, 19, 19, 19, 19, 20, 20, 19, 20, 19, 19, 19, 19, 20, 20, 20, 19, 19, 19,
20, 19, 19, 20, 20, 19, 20, 20, 20, 19, 19, 20, 19, 20, 20, 19, 20, 19, 20, 20,
19, 18, 19, 19, 19, 19, 19, 20, 20, 19, 19, 19, 18, 19, 19, 19, 19, 19, 19, 18,
19, 19, 19, 19, 19, 19, 19, 19, 18, 20, 19, 20, 19, 20, 19, 20, 19, 19, 19, 19,
20, 20, 19, 18, 19, 18, 21, 16, 22, -71, -117, -90, -88, -72, -69, -57, -53,
-44, -40, -33, -29, -24, -21, -17, -13, -10, -8, -5, -3, -1, };