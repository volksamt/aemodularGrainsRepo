#define DATA_LENGTH 512
#define DATA AKWF_1566

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 2, 2, 3, 3, 3, 4, 4, 5, 5,
5, 6, 6, 7, 7, 7, 7, 9, 9, 9, 10, 10, 10, 10, 11, 12, 11, 12, 12, 12, 14, 13,
14, 14, 15, 14, 15, 15, 16, 16, 15, 16, 17, 17, 17, 17, 17, 18, 18, 19, 18, 18,
19, 19, 20, 20, 20, 20, 20, 21, 20, 21, 21, 21, 21, 22, 22, 22, 22, 22, 23, 23,
23, 23, 24, 24, 24, 23, 23, 24, 24, 23, 24, 24, 25, 24, 24, 24, 25, 25, 24, 25,
25, 24, 26, 25, 25, 25, 24, 26, 26, 25, 25, 25, 26, 26, 26, 26, 25, 25, 26, 26,
26, 26, 26, 26, 26, 25, 26, 25, 26, 26, 26, 26, 26, 25, 26, 25, 26, 26, 26, 26,
26, 25, 26, 25, 25, 26, 25, 25, 25, 25, 25, 26, 26, 25, 25, 25, 25, 25, 25, 25,
24, 25, 24, 25, 25, 24, 25, 24, 24, 24, 24, 23, 24, 23, 24, 23, 24, 23, 23, 23,
23, 23, 23, 23, 22, 22, 22, 22, 22, 22, 22, 22, 22, 21, 21, 21, 21, 21, 22, 20,
20, 21, 19, 20, 20, 20, 20, 20, 19, 19, 19, 19, 19, 19, 18, 18, 19, 18, 18, 18,
18, 17, 18, 17, 17, 17, 17, 17, 16, 17, 15, 16, 16, 16, 15, 16, 16, 16, 14, 15,
14, 15, 14, 14, 13, 14, 13, 13, 13, 13, 13, 12, 13, 12, 13, 12, 12, 11, 11, 11,
12, 10, 11, 11, 11, 10, 10, 10, 9, 9, 9, 10, 9, 9, 9, 9, 9, 8, 8, 8, 8, 7, 8, 7,
7, 6, 6, 6, 7, 6, 6, 5, 5, 5, 4, 4, 5, 5, 4, 4, 4, 3, 3, 4, 3, 3, 3, 3, 2, 2, 1,
2, 1, 1, 1, 0, 0, 0, 1, 0, 0, 0, -1, -1, -1, -1, -2, -2, -3, -3, -3, -2, -3, -3,
-4, -4, -3, -4, -3, -4, -4, -5, -5, -5, -5, -6, -6, -6, -6, -6, -7, -7, -6, -7,
-7, -8, -7, -8, -8, -8, -8, -9, -9, -9, -9, -9, -10, -10, -9, -10, -11, -11,
-11, -11, -11, -12, -12, -13, -12, -12, -12, -13, -13, -13, -13, -14, -13, -14,
-14, -14, -15, -16, -15, -15, -16, -16, -16, -15, -16, -16, -17, -17, -64, -105,
-105, -109, -109, -111, -111, -113, -113, -115, -115, -115, -116, -116, -118,
-117, -119, -117, -117, -118, -118, -119, -118, -119, -118, -118, -118, -118,
-117, -118, -85, -41, -38, -36, -32, -28, -21, -14, -7, 0, 5, 7, 7, 5, 2, -3,
-7, -13, -16, -18, -18, -18, -16, -15, -12, -10, -9, -10, -11, -12, -13, -16,
-18, -20, -21, -20, -21, -20, -18, -17, -16, -14, -15, -15, -16, -15, -16, -17,
-18, -18, -17, -17, -16, -15, -14, -13, -13, -13, -12, -11, -12, -11, -11, -10,
-11, -11, -10, -9, -9, -8, -8, -7, -5, -5, -4, -4, -4, -4, -4, -3, -2, -2, -1,
-1, 0, };