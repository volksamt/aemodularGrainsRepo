#define DATA_LENGTH 512
#define DATA AKWF_1588

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 51, 71, 69, 75, 78, 85, 93, 101,
108, 115, 118, 119, 117, 113, 107, 101, 96, 91, 87, 85, 84, 86, 87, 88, 91, 91,
91, 89, 87, 85, 81, 78, 75, 73, 71, 71, 71, 71, 72, 73, 74, 74, 72, 71, 70, 69,
68, 66, 65, 63, 64, 64, 64, 64, 65, 64, 64, 64, 64, 63, 62, 62, 61, 60, 59, 60,
60, 59, 60, 60, 60, 60, 60, 60, 59, 60, 59, 58, 59, 57, 58, 58, 58, 58, 58, 57,
57, 57, 57, 57, 57, 57, 56, 56, 57, 56, 55, 55, 56, 54, 54, 55, 55, 55, 54, 54,
54, 54, 54, 54, 54, 53, 53, 52, 52, 52, 52, 52, 52, 52, 51, 51, 51, 51, 51, 51,
50, 50, 50, 49, 49, 49, 50, 49, 49, 48, 48, 48, 48, 47, 47, 48, 46, 47, 46, 46,
46, 46, 45, 45, 44, 44, 44, 44, 44, 44, 43, 44, 43, 42, 42, 43, 42, 41, 41, 42,
42, 41, 40, 41, 40, 40, 40, 39, 40, 39, 39, 38, 38, 39, 38, 38, 37, 37, 37, 36,
36, 36, 36, 35, 35, 35, 35, 35, 35, 34, 34, 34, 33, 33, 33, 32, 32, 32, 31, 32,
31, 31, 31, 31, 31, 31, 29, 29, 29, 28, 28, 29, 28, 28, 28, 28, 27, 27, 26, 27,
27, 26, 26, 26, 25, 25, 25, 25, 24, 25, 23, 24, 23, 22, 22, 22, 22, 21, 22, 21,
21, 20, 20, 21, 21, 20, 19, 20, 19, 19, 19, 18, 18, 18, 17, 17, 17, 17, 16, 16,
17, 15, 15, 16, 15, 14, 15, 13, 14, 14, 13, 12, 12, 13, 12, 12, 12, 11, 11, 11,
11, 10, 10, 10, 10, 9, 9, 9, 8, 9, 8, 8, 7, 7, 6, 7, 6, 6, 5, 7, 5, 5, 4, 6, 2,
6, -4, -73, -99, -101, -104, -105, -106, -107, -109, -108, -111, -111, -112,
-111, -113, -113, -114, -114, -114, -114, -115, -114, -115, -114, -116, -115,
-115, -115, -114, -114, -115, -114, -114, -113, -114, -113, -112, -112, -112,
-111, -111, -109, -109, -108, -107, -107, -107, -107, -106, -104, -105, -104,
-103, -103, -102, -100, -99, -100, -99, -98, -98, -97, -96, -94, -94, -93, -93,
-92, -91, -90, -89, -88, -88, -87, -86, -86, -84, -84, -84, -82, -82, -80, -81,
-79, -78, -78, -77, -76, -75, -75, -74, -73, -72, -72, -71, -70, -69, -69, -67,
-67, -67, -65, -65, -64, -64, -62, -63, -61, -61, -61, -60, -58, -58, -58, -57,
-56, -56, -55, -55, -54, -53, -53, -52, -51, -51, -51, -50, -50, -49, -48, -48,
-48, -46, -47, -46, -46, -45, -44, -44, -43, -42, -42, -42, -41, -40, -40, -39,
-39, -39, -39, -38, -37, -37, -37, -37, -35, -35, -34, -34, -34, -35, -34, -34,
-32, -32, -33, -32, -32, -32, -31, -30, -30, -30, -30, -29, -29, -29, -27, -28,
-28, -28, -27, -27, -27, -26, -26, -26, -25, -25, -26, -24, -26, -24, -25, -24,
-25, -23, -25, -21, };