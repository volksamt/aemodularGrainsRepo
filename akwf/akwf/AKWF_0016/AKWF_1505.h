#define DATA_LENGTH 512
#define DATA AKWF_1505

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 5, 6, 5, 6, 5, 6, 15, 16, 15, 16,
15, 16, 22, 26, 25, 25, 25, 25, 27, 35, 36, 36, 36, 36, 36, 39, 42, 40, 47, 47,
46, 49, 53, 51, 52, 52, 53, 58, 56, 61, 62, 62, 63, 62, 63, 63, 68, 73, 72, 72,
73, 74, 72, 74, 78, 77, 78, 79, 83, 83, 83, 83, 87, 89, 88, 88, 87, 89, 87, 90,
93, 96, 99, 98, 99, 99, 98, 99, 98, 99, 99, 98, 100, 106, 109, 109, 109, 108,
109, 109, 109, 108, 108, 109, 109, 109, 109, 109, 113, 114, 114, 113, 117, 120,
119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 118, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119,
119, 119, 119, 119, 120, 116, 112, 114, 114, 113, 113, 114, 114, 114, 114, 114,
115, 114, 114, 114, 114, 113, 108, 108, 109, 109, 109, 109, 109, 107, 109, 108,
110, 107, 103, 100, 98, 98, 98, 98, 98, 99, 95, 93, 94, 93, 93, 93, 93, 92, 89,
88, 88, 88, 83, 83, 83, 81, 77, 78, 78, 78, 77, 78, 75, 72, 72, 67, 67, 68, 68,
64, 62, 62, 61, 62, 62, 62, 57, 51, 51, 52, 51, 53, 50, 47, 46, 47, 43, 41, 41,
35, 37, 37, 36, 37, 36, 29, 25, 26, 25, 26, 25, 27, 23, 17, 16, 16, 16, 16, 16,
13, 9, 5, 6, 5, 5, 5, 1, -1, -6, -4, -6, -4, -6, -10, -12, -16, -16, -16, -15,
-16, -17, -24, -26, -26, -26, -26, -26, -25, -29, -35, -36, -36, -36, -36, -36,
-41, -41, -43, -47, -46, -46, -51, -52, -51, -53, -52, -52, -57, -63, -62, -62,
-61, -62, -62, -64, -68, -67, -68, -67, -72, -72, -75, -79, -78, -79, -77, -78,
-77, -80, -83, -82, -85, -88, -89, -88, -89, -92, -94, -93, -94, -92, -94, -92,
-94, -99, -98, -99, -98, -99, -98, -101, -103, -107, -110, -108, -109, -108,
-109, -109, -108, -109, -109, -109, -109, -114, -114, -113, -114, -114, -114,
-113, -114, -113, -114, -114, -114, -114, -115, -115, -114, -116, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -118, -120, -118, -118, -119, -119, -118, -120, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -117, -114, -114,
-114, -113, -109, -109, -108, -109, -109, -109, -109, -109, -109, -109, -109,
-108, -108, -108, -106, -99, -98, -98, -99, -98, -99, -99, -99, -99, -98, -98,
-95, -92, -89, -87, -89, -87, -88, -87, -88, -86, -82, -83, -83, -83, -78, -77,
-78, -78, -73, -71, -73, -73, -73, -72, -73, -68, -62, -62, -62, -62, -63, -62,
-61, -57, -58, -53, -52, -52, -51, -53, -48, -46, -48, -46, -41, -43, -38, -35,
-37, -36, -36, -37, -34, -26, -27, -25, -26, -26, -26, -21, -16, -15, -15, -16,
-16, -16, -6, -4, -5, -4, -6, -6, -5, };