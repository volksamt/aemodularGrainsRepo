#define DATA_LENGTH 512
#define DATA AKWF_1546

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 7, 10, 11, 13, 15, 16, 17,
18, 19, 20, 20, 21, 21, 23, 24, 23, 24, 24, 25, 25, 26, 26, 27, 26, 28, 26, 28,
26, 28, 27, 28, 27, 28, 29, 28, 25, -80, -108, -83, -80, -64, -61, -49, -45,
-35, -32, -24, -21, -16, -12, -8, -5, -2, 0, 3, 5, 6, 10, 11, 13, 15, 16, 17,
19, 19, 20, 21, 22, 22, 23, 23, 24, 24, 25, 25, 26, 26, 26, 27, 27, 27, 28, 27,
28, 27, 28, 28, 28, 28, 28, 28, 28, 28, 28, 29, 29, 28, 28, 28, 29, 29, 29, 28,
29, 29, 28, 28, 29, 29, 29, 29, 28, 28, 29, 28, 29, 29, 29, 29, 28, 28, 29, 28,
29, 28, 29, 28, 28, 29, 29, 29, 29, 29, 29, 28, 29, 28, 29, 28, 29, 29, 29, 29,
29, 29, 29, 29, 29, 29, 29, 28, 28, 29, 28, 28, 28, 29, 28, 28, 28, 29, 28, 28,
29, 28, 28, 29, 28, 28, 29, 29, 29, 28, 28, 28, 28, 28, 29, 29, 29, 28, 28, 28,
28, 28, 28, 28, 28, 28, 28, 28, 29, 27, 28, 28, 28, 28, 28, 28, 28, 28, 29, 28,
29, 28, 28, 29, 28, 29, 27, 28, 28, 28, 27, 29, 27, 29, 27, 29, 27, 29, 27, 31,
9, -91, -121, -117, -120, -117, -120, -119, -120, -118, -120, -119, -119, -119,
-120, -118, -120, -119, -120, -118, -119, -119, -119, -118, -118, -119, -119,
-118, -120, -118, -120, -118, -118, -118, -118, -118, -118, -119, -118, -118,
-118, -119, -117, -119, -117, -121, -116, -122, -112, -128, -60, 34, 26, 31, 28,
30, 28, 29, 29, 30, 29, 29, 30, 29, 30, 29, 29, 29, 29, 29, 30, 28, 30, 29, 29,
29, 29, 29, 30, 29, 30, 30, 29, 29, 30, 29, 30, 30, 28, 29, 29, 29, 29, 28, 30,
30, 29, 29, 29, 29, 28, 29, 29, 29, 29, 29, 29, 30, 29, 29, 30, 29, 29, 29, 29,
29, 30, 29, 29, 28, 29, 29, 29, 29, 29, 29, 29, 29, 28, 29, 28, 29, 29, 28, 29,
29, 29, 29, 29, 28, 29, 29, 29, 29, 29, 28, 29, 29, 28, 29, 28, 29, 29, 29, 29,
28, 28, 29, 28, 29, 28, 28, 28, 28, 29, 29, 28, 28, 28, 28, 28, 28, 29, 28, 28,
29, 29, 29, 29, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 29, 28, 28, 29, 28, 29,
28, 28, 28, 29, 27, 29, 28, 28, 28, 28, 28, 28, 28, 28, 29, 28, 28, 28, 29, 28,
28, 28, 29, 28, 28, 27, 28, 29, 28, 29, 28, 28, 28, 28, 28, 29, 26, 29, 27, 29,
27, 30, 25, 33, -6, -104, -119, -118, -119, -118, -118, -117, -119, -118, -119,
-119, -119, -118, -118, -118, -119, -118, -120, -119, -118, -118, -118, -118,
-119, -118, -118, -119, -118, -119, -115, -97, -88, -76, -66, -58, -50, -43,
-35, -31, -25, -20, -15, -12, -7, -5, -2, };