#define DATA_LENGTH 512
#define DATA AKWF_1551

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 6, 8, 9, 10, 10, 10, 12,
12, 13, 13, 14, 15, 15, 15, 15, 16, 16, 16, 16, 17, 17, 17, 17, 17, 17, 17, 18,
18, 18, 18, 19, 17, 18, 18, 19, 18, 18, 19, 19, 19, 19, 19, 18, 19, 19, 18, 19,
18, 19, 18, 18, 18, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 18, 18, 18, 19,
19, 18, 18, 19, 19, 18, 19, 18, 19, 19, 19, 18, 19, 19, 19, 18, 18, 19, 18, 18,
19, 19, 19, 19, 18, 18, 18, 19, 19, 19, 19, 18, 18, 19, 19, 18, 18, 18, 18, 18,
18, 18, 18, 19, 18, 18, 18, 19, 18, 19, 19, 18, 18, 18, 18, 18, 18, 19, 17, 19,
19, 19, 19, 19, 18, 19, 18, 19, 18, 18, 19, 18, 19, 18, 18, 18, 19, 18, 19, 17,
19, 16, 18, 17, 19, 18, 19, 18, 19, 17, 19, 18, 18, 19, 17, 14, -94, -126, -113,
-123, -116, -122, -117, -121, -117, -120, -118, -120, -119, -120, -118, -119,
-118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119,
-118, -119, -118, -119, -118, -119, -119, -119, -118, -119, -118, -118, -118,
-119, -118, -118, -117, -119, -117, -119, -111, -11, 29, 15, 21, 16, 20, 18, 21,
19, 20, 18, 19, 19, 20, 19, 20, 19, 20, 20, 19, 19, 19, 19, 19, 20, 18, 19, 20,
20, 19, 19, 19, 19, 20, 20, 19, 19, 19, 19, 20, 20, 19, 20, 19, 20, 20, 19, 20,
19, 19, 19, 19, 19, 19, 20, 19, 19, 19, 19, 20, 19, 19, 19, 19, 20, 19, 19, 19,
19, 19, 19, 19, 20, 20, 19, 20, 19, 19, 19, 19, 19, 19, 19, 19, 20, 20, 19, 20,
19, 19, 19, 19, 18, 19, 19, 19, 19, 19, 19, 20, 19, 19, 19, 19, 19, 18, 19, 19,
18, 19, 19, 19, 19, 19, 19, 19, 19, 18, 18, 18, 18, 19, 19, 19, 19, 19, 19, 19,
19, 18, 18, 19, 19, 19, 18, 20, 19, 19, 18, 20, 18, 21, 17, 22, 14, 28, -8, -96,
-96, -86, -76, -67, -60, -52, -45, -40, -35, -29, -26, -20, -18, -14, -12, -7,
-6, -3, -2, 2, 2, 4, 6, 7, 8, 9, 9, 12, 12, 13, 13, 13, 14, 14, 15, 15, 16, 17,
17, 16, 17, 17, 18, 17, 17, 18, 18, 18, 18, 19, 18, 19, 19, 19, 18, 18, 19, 19,
19, 19, 18, 19, 19, 19, 19, 18, 19, 19, 19, 19, 19, 20, 19, 19, 19, 18, 19, 19,
19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 18, 18, 19, 19, 19, 19, 19, 19,
19, 19, 19, 18, 19, 19, 19, 19, 19, 19, 19, 19, 19, 20, 19, 19, 19, 19, 18, 20,
18, 19, 18, 20, 18, 20, 16, 23, -19, -104, -96, -82, -75, -66, -59, -50, -46,
-38, -34, -28, -25, -20, -17, -14, -11, -7, -5, -3, -1, };