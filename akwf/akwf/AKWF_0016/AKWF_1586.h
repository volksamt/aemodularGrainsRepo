#define DATA_LENGTH 512
#define DATA AKWF_1586

const PROGMEM int8_t DATA[DATA_LENGTH] = {29, 74, 75, 77, 81, 86, 92, 98, 107,
113, 118, 118, 119, 116, 111, 104, 99, 93, 88, 85, 84, 83, 85, 86, 88, 88, 89,
87, 86, 83, 80, 77, 73, 71, 69, 67, 67, 66, 67, 68, 68, 68, 67, 67, 66, 64, 62,
61, 59, 57, 56, 57, 55, 56, 57, 57, 56, 56, 56, 54, 54, 53, 53, 51, 50, 50, 50,
50, 49, 50, 49, 50, 50, 49, 48, 48, 48, 48, 47, 46, 45, 45, 45, 45, 45, 45, 44,
44, 44, 45, 44, 43, 43, 42, 42, 42, 41, 41, 42, 40, 40, 40, 40, 40, 40, 39, 39,
39, 38, 37, 37, 37, 38, 37, 36, 36, 36, 35, 36, 36, 36, 34, 35, 33, 34, 32, 36,
17, -48, -66, -66, -69, -69, -71, -72, -73, -73, -75, -75, -76, -76, -77, -77,
-78, -77, -79, -79, -79, -79, -80, -79, -79, -79, -79, -79, -79, -79, -79, -79,
-79, -78, -78, -77, -77, -77, -76, -76, -75, -74, -75, -73, -73, -73, -72, -72,
-72, -71, -69, -69, -68, -68, -67, -66, -66, -66, -64, -65, -63, -62, -62, -62,
-61, -60, -60, -59, -58, -57, -57, -55, -56, -54, -54, -53, -52, -51, -51, -51,
-50, -49, -48, -48, -46, -46, -45, -44, -44, -43, -43, -42, -41, -41, -40, -39,
-39, -38, -37, -36, -35, -36, -34, -34, -33, -32, -32, -32, -30, -30, -29, -29,
-28, -28, -27, -27, -26, -26, -25, -25, -24, -24, -24, -23, -23, -21, -21, -21,
-20, -20, -19, -18, -18, -17, -18, -18, -16, -16, -16, -15, -14, -14, -14, -14,
-13, -13, -12, -13, -11, -11, -10, -10, -9, -10, -9, -9, -8, -8, -8, -8, -8, -7,
-7, -6, -6, -6, -5, -4, -6, -4, -4, -4, -3, -4, -4, -3, -2, -2, -2, -2, -3, -2,
-1, -1, -1, 0, -1, -1, 0, 1, 0, 1, 1, 0, 1, 0, 1, 1, 2, 1, 2, 2, 3, 3, 2, 2, 2,
3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 5, 4, 3, 4, 4, 5, 4, 5, 5, 5, 5, 4, 5, 5, 4, 5, 5,
5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 6, 5, 5, 6, 5, 5, 5, 5, 5, 5, 5, 5, 5,
5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 4, 5, 4, 4, 4, 4, 4, 4, 5, 4, 3, 4, 4, 4, 3, 3,
3, 3, 4, 2, 3, 3, 3, 2, 2, 3, 2, 2, 2, 2, 2, 2, 1, 2, 1, 1, 2, 1, 2, 1, 1, 1, 0,
0, 0, 0, 0, 1, -1, 0, -1, 0, 0, -1, -1, -1, 0, -2, -2, -1, -2, -2, -2, -2, -2,
-3, -3, -3, -3, -4, -3, -4, -3, -3, -5, -5, -4, -5, -4, -4, -5, -4, -5, -5, -5,
-5, -5, -6, -6, -5, -7, -7, -7, -7, -8, -7, -8, -8, -8, -8, -7, -8, -8, -9, -9,
-8, -9, -9, -10, -9, -9, -12, -6, };