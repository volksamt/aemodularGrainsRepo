#define DATA_LENGTH 512
#define DATA AKWF_1563

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 5, 10, 14, 22, 29, 37, 44, 50,
53, 53, 52, 49, 44, 38, 34, 30, 27, 25, 27, 28, 30, 33, 34, 35, 36, 34, 33, 31,
29, 26, 24, 22, 22, 23, 23, 24, 25, 26, 26, 27, 27, 26, 26, 24, 23, 22, 22, 22,
22, 22, 24, 25, 25, 25, 25, 26, 26, 26, 25, 26, 26, 25, 25, 25, 25, 26, 27, 28,
27, 29, 28, 28, 29, 28, 28, 29, 29, 29, 28, 29, 30, 30, 30, 31, 31, 31, 31, 31,
31, 32, 32, 32, 31, 33, 33, 33, 33, 34, 33, 34, 33, 34, 34, 34, 33, 34, 35, 34,
34, 35, 34, 35, 35, 35, 35, 36, 35, 36, 36, 35, 36, 35, 36, 36, 36, 36, 36, 36,
37, 36, 36, 37, 36, 36, 36, 36, 37, 36, 36, 36, 36, 37, 36, 36, 36, 36, 37, 37,
36, 36, 36, 36, 36, 36, 37, 36, 36, 36, 36, 36, 36, 35, 35, 36, 35, 35, 36, 36,
35, 34, 36, 35, 35, 35, 35, 36, 36, 34, 34, 35, 35, 34, 35, 34, 35, 34, 34, 33,
34, 35, 34, 34, 33, 34, 33, 33, 33, 33, 32, 32, 32, 32, 32, 32, 32, 32, 32, 31,
32, 32, 31, 31, 31, 31, 31, 30, 31, 30, 30, 30, 30, 30, 29, 30, 29, 29, 29, 29,
29, 28, 28, 29, 29, 28, 27, 28, 28, 27, 27, 28, 27, 27, 26, 27, 25, 26, 25, 25,
25, 25, 25, 25, 25, 25, 24, 24, 25, 24, 24, 23, 23, 23, 23, 23, 22, 22, 23, 21,
22, 21, 21, 21, 21, 21, 21, 20, 20, 20, 20, 20, 19, 19, 19, 20, 20, 18, 18, 18,
17, 18, 18, 17, 18, 17, 17, 17, 16, 15, 16, 15, 16, 15, 15, 15, 14, 15, 14, 14,
14, 14, 13, 13, 13, 13, 12, 12, 12, 12, 11, 12, 12, 11, 11, 10, 10, 10, 9, 10,
10, 9, 9, 9, 8, 8, 8, 9, 8, 8, 7, 7, 8, 6, 7, 7, 6, 5, 6, 5, 5, 5, 4, 5, 4, 3,
4, 3, 3, 3, 3, 2, 2, 2, 1, 2, 2, 1, 2, 0, 1, 0, 0, 0, 0, -1, 0, -1, -1, -1, -1,
-1, -2, -3, -3, -2, -3, -3, -4, -3, -3, -4, -5, -4, -5, -5, -6, -6, -6, -6, -6,
-6, -6, -7, -6, -7, -8, -7, -8, -8, -8, -8, -8, -8, -10, -8, -11, -9, -10, -9,
-11, -10, -13, -8, -15, -73, -106, -107, -109, -110, -111, -112, -114, -113,
-115, -115, -116, -116, -117, -118, -118, -118, -118, -118, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -119, -119, -117, -117, -117, -117,
-116, -117, -116, -115, -115, -115, -114, -112, -112, -113, -111, -110, -110,
-109, -109, -108, -108, -108, -106, -106, -105, -105, -104, -103, -102, -101,
-102, -100, -100, -99, -98, -98, -96, -97, -95, -94, -93, -92, -92, -92, -90,
-90, -89, -88, -87, -87, -86, -86, -84, -86, -73, -22, };