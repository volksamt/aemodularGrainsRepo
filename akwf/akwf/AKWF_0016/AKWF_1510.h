#define DATA_LENGTH 512
#define DATA AKWF_1510

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 24, 23, 25, 23, 24, 23, 24, 23,
24, 23, 25, 22, 26, 20, 38, 50, 47, 48, 48, 46, 61, 75, 70, 73, 69, 73, 70, 73,
69, 77, 96, 95, 95, 95, 96, 95, 96, 95, 95, 95, 95, 95, 95, 96, 95, 96, 95, 95,
95, 95, 95, 95, 96, 95, 95, 96, 95, 95, 95, 95, 95, 96, 95, 95, 95, 95, 95, 95,
96, 93, 101, 121, 117, 120, 118, 120, 118, 119, 118, 120, 117, 95, 95, 95, 95,
96, 95, 96, 93, 98, 79, 69, 72, 71, 71, 72, 71, 72, 71, 73, 62, 45, 49, 47, 48,
48, 48, 48, 47, 49, 46, 51, 35, 21, 24, 22, 24, 23, 24, 24, 24, 24, 23, 24, 23,
24, 24, 23, 24, 23, 25, 7, -2, 2, -1, 1, -1, 1, -1, 0, -1, 0, -1, 1, 0, 1, 0, 0,
0, 2, -1, 3, -9, -27, -23, -25, -24, -24, -23, -24, -24, -24, -24, -24, -24,
-24, -24, -24, -25, -24, -23, -23, -23, -24, -23, -24, -24, -23, -23, -23, -24,
-24, -24, -24, -24, -24, -23, -23, -23, -24, -23, -24, -24, -24, -24, -24, -24,
-24, -23, -24, -23, -23, -24, -24, -24, -24, -24, -24, -24, -23, -24, -24, -25,
-23, -24, -23, -24, -23, -24, -43, -51, -40, -22, -24, -24, -23, -24, -23, -24,
-24, -25, -23, -24, -23, -24, -24, -24, -24, -24, -24, -25, -24, -25, -24, -24,
-24, -24, -24, -4, 1, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 22, 26, 23, 25, 23, 24,
23, 25, 23, 24, 24, 24, 23, 24, 24, 24, 24, 24, 24, 24, 24, 23, 25, 23, 25, 21,
35, 51, 47, 27, 22, 25, 24, 25, 24, 24, 23, 24, 24, 24, 24, 23, 24, 23, 24, 23,
24, 24, 25, 24, 24, 24, 24, 24, 23, 24, 24, 24, 24, 24, 24, 24, 23, 24, 23, 24,
24, 24, 24, 24, 24, 24, 24, 24, 24, 24, 24, 23, 24, 24, 23, 23, 24, 24, 24, 23,
24, 23, 24, 24, 25, 22, 25, 22, 27, 15, -3, 1, -1, 0, -1, 0, -1, 1, 0, 1, -1, 1,
-1, 0, -1, 1, 0, 0, 0, 1, -2, -24, -24, -23, -24, -23, -24, -23, -24, -24, -24,
-24, -23, -24, -24, -25, -24, -26, -21, -31, -50, -47, -48, -48, -47, -48, -47,
-49, -46, -49, -45, -57, -73, -71, -72, -72, -70, -71, -70, -72, -70, -75, -96,
-96, -95, -96, -95, -97, -95, -97, -92, -113, -121, -117, -120, -118, -120,
-117, -120, -117, -122, -107, -93, -97, -94, -96, -95, -96, -94, -95, -95, -96,
-96, -95, -96, -96, -95, -94, -96, -95, -95, -95, -95, -96, -95, -94, -96, -96,
-96, -95, -96, -95, -95, -95, -95, -95, -95, -95, -95, -95, -94, -99, -83, -68,
-74, -69, -73, -70, -73, -70, -74, -66, -47, -47, -48, -47, -49, -43, -22, -25,
-24, -24, -24, -24, -23, -24, -24, -24, -24, -24, -24, -23, -25, -3, 0, };