#define DATA_LENGTH 512
#define DATA AKWF_1561

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 8, 8, 10, 11, 12, 13, 14,
16, 17, 18, 18, 19, 20, 22, 22, 22, 24, 24, 25, 25, 25, 27, 27, 27, 28, 29, 29,
30, 30, 30, 31, 31, 30, 32, 32, 32, 32, 33, 33, 33, 33, 33, 34, 33, 34, 34, 34,
34, 34, 35, 36, 35, 35, 36, 35, 36, 36, 36, 36, 36, 36, 37, 37, 36, 37, 37, 37,
36, 36, 37, 36, 37, 36, 37, 37, 37, 37, 37, 37, 37, 37, 37, 36, 38, 37, 37, 37,
37, 37, 37, 37, 37, 38, 37, 38, 37, 37, 37, 38, 37, 38, 37, 37, 38, 38, 37, 37,
38, 37, 37, 37, 38, 37, 37, 37, 38, 38, 38, 37, 37, 37, 37, 38, 37, 38, 38, 37,
38, 37, 38, 38, 38, 38, 37, 37, 37, 38, 38, 37, 37, 38, 37, 38, 38, 37, 37, 37,
37, 37, 37, 37, 37, 37, 37, 38, 37, 37, 38, 37, 37, 37, 36, 37, 37, 37, 38, 36,
36, 37, 37, 37, 38, 37, 37, 37, 36, 37, 38, 37, 37, 37, 38, 37, 36, 37, 37, 37,
37, 37, 37, 36, 37, 37, 36, 36, 37, 37, 37, 36, 37, 36, 37, 37, 37, 36, 37, 37,
37, 37, 37, 37, 36, 36, 36, 37, 37, 37, 37, 37, 36, 36, 36, 37, 37, 37, 37, 36,
37, 36, 37, 36, 37, 37, 37, 36, 37, 37, 37, 37, 36, 36, 36, 36, 36, 36, 37, 36,
36, 36, 37, 36, 36, 36, 36, 37, 37, 37, 36, 36, 36, 36, 36, 36, 36, 37, 37, 36,
36, 36, 36, 37, 36, 36, 36, 35, 35, 37, 36, 36, 36, 36, 36, 36, 36, 36, 36, 37,
36, 37, 36, 35, 36, 35, 36, 36, 37, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36,
36, 36, 36, 36, 35, 36, 36, 36, 35, 35, 36, 35, 35, 35, 36, 36, 36, 35, 36, 36,
35, 35, 35, 35, 36, 35, 35, 35, 36, 35, 36, 35, 36, 36, 36, 35, 36, 33, 49, 23,
-89, -124, -115, -120, -117, -121, -118, -119, -119, -119, -118, -120, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -118,
-118, -119, -118, -119, -118, -118, -118, -119, -118, -118, -118, -119, -118,
-118, -118, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117,
-117, -118, -118, -118, -118, -118, -118, -117, -118, -118, -117, -117, -118,
-117, -118, -118, -117, -117, -118, -117, -117, -116, -121, -78, 30, 49, 34, 37,
36, 38, 36, 38, 37, 38, 37, 37, 36, 37, 38, 37, 38, 38, 37, 37, 37, 38, 37, 37,
37, 37, 36, 40, 35, 7, -51, -104, -100, -87, -83, -77, -73, -68, -63, -58, -54,
-49, -45, -41, -39, -34, -31, -29, -25, -21, -19, -17, -14, -11, -10, -7, -5,
-3, -1, };