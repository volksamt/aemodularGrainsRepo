#define DATA_LENGTH 512
#define DATA AKWF_1560

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 9, 11, 14, 16, 17, 20, 21, 23,
23, 25, 26, 27, 29, 29, 30, 30, 30, 32, 32, 32, 32, 33, 34, 33, 35, 35, 35, 34,
35, 35, 35, 35, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 37, 36, 36, 36, 37, 36,
37, 36, 36, 37, 36, 37, 36, 37, 37, 37, 36, 36, 36, 37, 37, 36, 36, 37, 37, 36,
36, 37, 36, 37, 36, 37, 36, 37, 36, 36, 37, 36, 37, 37, 36, 35, 37, 37, 36, 36,
36, 36, 36, 37, 36, 36, 36, 36, 36, 36, 36, 36, 36, 37, 36, 37, 36, 36, 35, 36,
36, 36, 36, 36, 36, 36, 36, 36, 35, 36, 35, 36, 36, 36, 36, 36, 35, 35, 36, 36,
36, 36, 35, 35, 36, 36, 36, 36, 35, 36, 35, 36, 36, 36, 36, 36, 36, 35, 35, 35,
35, 36, 35, 35, 36, 36, 36, 34, 36, 35, 35, 34, 35, 35, 36, 35, 37, 34, 37, 32,
42, 10, -101, -121, -117, -121, -118, -119, -119, -119, -118, -120, -118, -120,
-118, -119, -118, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -118, -119, -118, -119, -118, -118, -119, -118, -120, -118, -119, -118,
-119, -117, -120, -117, -120, -117, -119, -116, -120, -115, -121, -95, 12, 43,
32, 39, 34, 40, 12, -83, -98, -75, -70, -57, -52, -40, -36, -27, -23, -16, -13,
-7, -4, 1, 3, 7, 9, 12, 14, 16, 18, 19, 22, 23, 25, 25, 26, 27, 28, 28, 30, 30,
31, 31, 32, 32, 32, 33, 34, 34, 34, 35, 35, 34, 35, 35, 35, 36, 35, 36, 36, 37,
36, 36, 36, 36, 36, 35, 35, 37, 36, 37, 37, 36, 36, 36, 36, 36, 37, 36, 36, 36,
35, 36, 36, 37, 37, 36, 37, 36, 36, 37, 37, 36, 37, 36, 36, 36, 37, 35, 36, 36,
36, 35, 36, 36, 36, 37, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36,
37, 36, 35, 37, 36, 36, 36, 36, 36, 37, 36, 36, 36, 36, 35, 36, 35, 36, 35, 36,
35, 36, 36, 36, 35, 36, 35, 35, 36, 35, 37, 36, 36, 35, 36, 35, 36, 36, 36, 36,
36, 35, 36, 36, 35, 36, 35, 36, 35, 37, 34, 36, 34, 36, 35, 37, 34, 35, 35, 35,
36, 35, 36, 35, 36, 34, 37, 33, 38, 31, 41, 25, 54, -19, -126, -113, -123, -116,
-120, -117, -120, -118, -119, -118, -118, -119, -119, -120, -119, -119, -118,
-120, -118, -119, -118, -120, -118, -119, -117, -119, -118, -119, -118, -118,
-118, -118, -119, -119, -118, -119, -119, -118, -118, -118, -117, -117, -118,
-117, -119, -118, -119, -115, -119, -26, 45, 31, 39, 34, 37, 35, 38, 35, 37, 36,
36, 35, 36, 35, 36, 36, 36, 37, 37, 37, 35, 37, 36, 37, 35, 37, 34, 38, 34, 42,
-29, -101, -84, -75, -62, -55, -46, -39, -32, -26, -19, -15, -10, -6, -3, 0, };