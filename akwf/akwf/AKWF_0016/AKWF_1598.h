#define DATA_LENGTH 512
#define DATA AKWF_1598

const PROGMEM int8_t DATA[DATA_LENGTH] = {100, 74, 65, 72, 65, 72, 66, 71, 66,
71, 67, 70, 67, 71, 68, 69, 68, 69, 67, 69, 68, 69, 69, 68, 69, 68, 69, 68, 69,
68, 69, 68, 69, 68, 69, 68, 68, 68, 69, 68, 69, 69, 69, 69, 69, 68, 68, 69, 68,
68, 69, 68, 69, 68, 68, 68, 69, 68, 68, 68, 67, 68, 68, 68, 69, 69, 68, 69, 69,
68, 68, 68, 68, 68, 68, 69, 68, 68, 68, 69, 68, 67, 68, 67, 68, 68, 68, 68, 68,
68, 68, 68, 68, 69, 68, 68, 67, 68, 68, 69, 68, 69, 68, 68, 68, 69, 68, 67, 67,
68, 68, 66, 69, 66, 69, 67, 69, 66, 69, 67, 70, 66, 69, 66, 70, 66, 70, 65, -31,
-40, -34, -38, -34, -38, -35, -39, -35, -38, -36, -38, -36, -39, -36, -38, -36,
-37, -36, -38, -36, -37, -37, -36, -36, -37, -37, -36, -38, -36, -36, -36, -38,
-36, -38, -36, -38, -35, -38, -35, -37, -35, -38, -35, -38, -34, -43, -104,
-105, -103, -105, -104, -105, -103, -106, -104, -106, -103, -105, -104, -106,
-104, -105, -103, -105, -104, -105, -104, -104, -105, -104, -105, -104, -105,
-104, -105, -103, -105, -104, -106, -104, -105, -104, -106, -104, -105, -104,
-104, -104, -104, -104, -104, -105, -103, -105, -102, -106, -101, -108, -97,
-116, -55, 13, -8, 4, -4, 2, -1, 1, -1, 0, 0, 1, 1, 0, 0, -1, 0, -1, 0, 0, 1, 0,
0, -1, 1, 0, 1, 0, 1, -1, 0, -1, 0, -1, 1, -1, 1, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0,
1, -1, 3, -3, 6, -12, 62, 116, 97, 108, 101, 106, 102, 106, 102, 105, 103, 105,
104, 105, 104, 104, 105, 104, 105, 104, 105, 104, 106, 104, 105, 103, 104, 103,
104, 104, 105, 104, 105, 104, 105, 104, 105, 105, 103, 105, 105, 105, 104, 106,
104, 105, 103, 106, 103, 106, 104, 106, 103, 107, 101, 39, 36, 38, 35, 38, 36,
38, 36, 38, 35, 38, 36, 37, 36, 38, 37, 37, 36, 37, 37, 38, 37, 37, 37, 37, 37,
36, 38, 36, 37, 36, 38, 36, 38, 36, 38, 35, 39, 36, 39, 35, 39, 34, 40, 33, 42,
26, -69, -68, -67, -69, -67, -68, -66, -69, -67, -69, -67, -69, -66, -69, -66,
-68, -67, -69, -68, -68, -68, -68, -68, -68, -67, -68, -68, -68, -68, -67, -68,
-68, -68, -67, -68, -68, -68, -68, -68, -68, -68, -68, -68, -67, -68, -68, -68,
-68, -67, -68, -68, -68, -68, -69, -68, -68, -68, -69, -67, -68, -67, -68, -69,
-68, -68, -68, -68, -68, -68, -67, -68, -68, -68, -68, -67, -69, -68, -68, -68,
-68, -68, -69, -68, -69, -69, -68, -68, -69, -68, -69, -68, -69, -68, -68, -68,
-68, -68, -69, -69, -69, -68, -69, -68, -69, -69, -69, -68, -69, -69, -68, -69,
-68, -69, -68, -70, -67, -71, -67, -71, -66, -71, -65, -72, -65, -73, -63, -78,
-99, };