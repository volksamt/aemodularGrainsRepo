#define DATA_LENGTH 512
#define DATA AKWF_1514

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 12, 17, 20, 24, 27, 32, 35,
38, 42, 45, 49, 52, 55, 59, 63, 65, 68, 71, 74, 77, 80, 83, 87, 88, 92, 94, 96,
99, 100, 103, 105, 107, 109, 111, 111, 113, 114, 116, 117, 117, 118, 118, 119,
119, 119, 119, 118, 119, 119, 118, 117, 116, 115, 114, 112, 112, 111, 109, 107,
106, 104, 103, 100, 99, 97, 96, 94, 92, 90, 88, 87, 85, 82, 81, 79, 77, 75, 73,
71, 69, 67, 66, 63, 62, 61, 58, 57, 55, 53, 52, 51, 50, 48, 47, 45, 43, 42, 42,
40, 39, 38, 37, 36, 35, 35, 33, 33, 33, 32, 32, 31, 30, 30, 29, 30, 28, 28, 27,
28, 27, 28, 27, 27, 26, 26, 26, 26, 26, 25, 26, 25, 24, 25, 25, 24, 23, 23, 23,
22, 22, 21, 20, 21, 19, 19, 19, 18, 16, 16, 15, 13, 13, 11, 10, 9, 7, 6, 5, 3,
1, -1, -3, -4, -5, -9, -10, -12, -14, -17, -19, -21, -23, -25, -29, -30, -33,
-36, -38, -39, -43, -45, -48, -50, -52, -56, -58, -61, -63, -65, -67, -70, -73,
-75, -77, -79, -81, -83, -86, -87, -88, -90, -91, -93, -93, -95, -95, -96, -96,
-96, -96, -95, -95, -94, -92, -92, -90, -87, -85, -83, -82, -80, -78, -76, -74,
-72, -70, -68, -65, -64, -61, -59, -57, -55, -52, -50, -46, -45, -43, -40, -37,
-33, -32, -29, -25, -23, -21, -17, -15, -13, -10, -7, -4, -1, 2, 5, 7, 10, 12,
16, 18, 20, 24, 26, 29, 32, 35, 37, 40, 42, 45, 47, 49, 52, 55, 57, 60, 61, 64,
66, 68, 70, 72, 75, 77, 78, 80, 82, 84, 85, 88, 89, 91, 94, 94, 95, 96, 96, 96,
96, 96, 95, 94, 93, 92, 91, 90, 87, 87, 85, 83, 81, 79, 77, 74, 72, 70, 68, 65,
63, 60, 58, 55, 52, 50, 47, 45, 43, 41, 37, 35, 33, 30, 28, 25, 22, 21, 18, 15,
13, 12, 9, 8, 6, 4, 3, 0, -2, -3, -4, -6, -7, -8, -10, -11, -12, -13, -15, -16,
-16, -18, -19, -19, -19, -20, -21, -21, -22, -23, -22, -23, -24, -24, -24, -24,
-25, -26, -25, -25, -26, -26, -27, -27, -26, -27, -27, -27, -27, -27, -29, -29,
-29, -30, -29, -30, -30, -31, -32, -32, -32, -33, -34, -34, -35, -36, -37, -38,
-39, -40, -41, -42, -44, -45, -46, -48, -49, -50, -52, -53, -55, -57, -58, -60,
-62, -64, -65, -67, -70, -71, -73, -74, -77, -80, -80, -83, -85, -86, -88, -91,
-93, -95, -97, -97, -100, -102, -103, -105, -105, -108, -108, -111, -111, -113,
-114, -115, -115, -117, -117, -118, -118, -118, -119, -119, -119, -119, -119,
-118, -118, -117, -116, -114, -112, -112, -110, -109, -107, -105, -103, -101,
-98, -96, -94, -91, -89, -86, -83, -80, -77, -74, -71, -68, -66, -62, -58, -55,
-53, -49, -45, -42, -38, -35, -32, -27, -24, -20, -17, -13, -8, -5, -1, };