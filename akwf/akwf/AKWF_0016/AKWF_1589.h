#define DATA_LENGTH 512
#define DATA AKWF_1589

const PROGMEM int8_t DATA[DATA_LENGTH] = {48, 81, 70, 75, 68, 71, 67, 67, 64,
64, 62, 61, 59, 58, 57, 56, 55, 53, 52, 50, 50, 48, 46, 45, 44, 43, 42, 40, 40,
38, 37, 35, 35, 32, 32, 31, 30, 28, 27, 26, 24, 24, 22, 20, 19, 19, 16, 16, 14,
14, 12, 11, 10, 9, 8, 7, 5, 5, 3, 1, 1, -1, -2, -3, -4, -6, -6, -8, -8, -10,
-11, -12, -14, -14, -16, -17, -17, -19, -19, -22, -21, -24, -23, -26, -26, -28,
-28, -31, -30, -32, -32, -35, -35, -37, -36, -40, -35, 33, 47, 42, 45, 41, 43,
40, 41, 39, 41, 39, 40, 39, 40, 38, 39, 37, 38, 38, 37, 36, 37, 36, 36, 36, 36,
35, 34, 36, 34, 35, 35, 33, 33, 33, 32, 33, 32, 31, 32, 31, 31, 30, 31, 30, 30,
31, 29, 30, 29, 29, 29, 28, 29, 27, 27, 27, 26, 27, 26, 25, 26, 26, 25, 24, 25,
24, 24, 24, 23, 23, 23, 23, 23, 22, 22, 22, 22, 21, 20, 21, 21, 20, 20, 20, 19,
20, 19, 18, 19, 18, 18, 18, 17, 17, 16, 17, 16, 16, 16, 16, 15, 16, 16, 15, 14,
14, 14, 14, 13, 14, 12, 13, 13, 13, 12, 12, 12, 12, 11, 10, 10, 11, 11, 10, 9,
9, 8, 9, 9, 9, 9, 8, 8, 8, 7, 7, 7, 6, 6, 6, 6, 6, 5, 6, 5, 5, 5, 5, 5, 5, 4, 4,
3, 4, 3, 3, 3, 2, 2, 2, 1, 1, 2, 1, 1, 1, 0, 1, 0, 0, 0, 0, -1, -1, -1, -1, -2,
-2, -2, -2, -3, -3, -3, -4, -3, -4, -4, -4, -4, -5, -4, -5, -5, -5, -5, -5, -6,
-6, -6, -6, -6, -6, -6, -7, -7, -8, -8, -8, -8, -8, -7, -8, -9, -8, -8, -9, -9,
-10, -9, -10, -9, -10, -10, -10, -10, -10, -11, -10, -10, -11, -11, -11, -12,
-11, -13, -12, -12, -13, -13, -12, -13, -14, -13, -14, -15, -14, -14, -14, -15,
-14, -16, -15, -15, -15, -15, -16, -16, -17, -17, -17, -17, -17, -18, -17, -18,
-18, -19, -18, -19, -19, -20, -19, -20, -20, -20, -20, -21, -21, -22, -21, -22,
-22, -23, -23, -23, -24, -24, -25, -25, -26, -26, -27, -27, -28, -29, -29, -31,
-32, -31, -32, -33, -34, -35, -36, -35, -37, -38, -37, -38, -40, -40, -42, -42,
-44, -43, -44, -46, -47, -46, -48, -48, -50, -50, -51, -51, -52, -54, -54, -55,
-56, -57, -58, -59, -60, -61, -61, -62, -63, -64, -66, -66, -68, -69, -69, -71,
-72, -72, -72, -74, -75, -76, -77, -78, -79, -80, -81, -83, -84, -85, -85, -86,
-87, -89, -89, -91, -91, -93, -94, -95, -96, -97, -98, -99, -100, -101, -101,
-104, -105, -107, -107, -109, -109, -111, -112, -113, -114, -116, -117, -117,
-119, -76, -60, -65, -66, -69, -70, -73, -74, -77, -78, -81, -82, -86, -87, -89,
-91, -94, -94, -98, -97, -104, -98, -114, -62, };