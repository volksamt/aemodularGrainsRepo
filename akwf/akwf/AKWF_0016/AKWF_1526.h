#define DATA_LENGTH 512
#define DATA AKWF_1526

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 37, 69, 90, 106, 113, 118, 118,
119, 118, 118, 117, 116, 114, 114, 112, 111, 110, 109, 107, 108, 106, 105, 104,
103, 103, 101, 100, 100, 98, 98, 97, 96, 90, 76, 56, 30, 3, -28, -55, -76, -90,
-99, -104, -106, -106, -105, -105, -104, -103, -103, -101, -101, -100, -99, -98,
-98, -95, -94, -94, -93, -92, -91, -90, -90, -88, -84, -75, -64, -49, -34, -18,
-1, 15, 30, 44, 58, 70, 81, 92, 100, 106, 109, 110, 111, 111, 110, 108, 108,
107, 107, 105, 104, 103, 101, 99, 94, 88, 81, 73, 66, 58, 49, 41, 32, 25, 17, 9,
2, -5, -13, -17, -24, -28, -33, -38, -41, -44, -47, -49, -50, -52, -52, -52,
-51, -49, -48, -46, -45, -42, -40, -36, -34, -31, -27, -23, -20, -15, -11, -9,
-4, -1, 2, 5, 8, 12, 14, 17, 19, 22, 23, 25, 26, 27, 28, 29, 30, 29, 30, 29, 30,
29, 28, 28, 26, 25, 24, 23, 21, 19, 19, 17, 15, 14, 12, 11, 10, 8, 6, 6, 5, 3,
1, 0, 0, -1, -3, -2, -3, -4, -3, -4, -5, -4, -4, -5, -4, -4, -4, -4, -3, -3, -2,
-2, -2, 0, 0, 0, 1, 1, 1, 1, 2, 2, 3, 3, 3, 3, 3, 4, 4, 4, 4, 3, 3, 2, 2, 2, 1,
2, 1, 1, 0, -1, -1, -2, -3, -4, -4, -5, -5, -6, -6, -8, -9, -9, -9, -10, -10,
-12, -12, -12, -12, -13, -13, -14, -14, -15, -15, -14, -16, -16, -16, -16, -15,
-16, -16, -16, -16, -15, -15, -15, -16, -15, -14, -14, -14, -13, -13, -13, -12,
-13, -11, -12, -12, -11, -11, -11, -11, -10, -10, -10, -10, -8, -8, -8, -8, -7,
-7, -7, -7, -7, -6, -6, -6, -6, -6, -5, -6, -6, -4, -6, -5, -4, -4, -4, -4, -5,
-3, -4, -4, -3, -4, -3, -3, -4, -3, -4, -3, -3, -3, -3, -3, -2, -2, -2, -3, -3,
-3, -2, -3, -2, -1, -2, -1, -2, -1, -2, -2, -2, -1, -1, -1, -1, -1, 0, -1, 0, 0,
-1, -1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 0, 1, 0, 2,
1, 1, 0, 1, 2, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 2,
1, 1, 1, 2, 1, 1, 2, 1, 2, 1, 1, 2, 1, 1, 1, 2, 1, 1, 2, 2, 1, 1, 1, 1, 1, 1, 1,
1, 2, 2, 1, 1, 2, 2, 1, 2, 2, 2, 1, 2, 2, 1, 2, 2, 2, 2, 1, 1, 1, 2, 1, 2, 2, 1,
1, 2, 1, 1, 1, 1, 2, 1, 1, 2, 1, 1, 2, 2, 1, -2, -8, -20, -36, -55, -70, -82,
-88, -92, -93, -94, -93, -94, -92, -92, -91, -89, -89, -87, -87, -86, -86, -84,
-84, -83, -82, -81, -81, -72, -55, -25, };