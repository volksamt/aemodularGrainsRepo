#define DATA_LENGTH 512
#define DATA AKWF_1555

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 3, 5, 6, 7, 8, 9, 11, 13, 14,
14, 15, 15, 16, 17, 17, 18, 18, 19, 19, 19, 20, 20, 21, 22, 22, 23, 23, 23, 23,
23, 24, 24, 24, 25, 24, 24, 25, 24, 25, 25, 25, 25, 25, 26, 26, 25, 26, 26, 26,
26, 26, 26, 26, 27, 26, 27, 26, 26, 26, 27, 27, 26, 27, 27, 27, 27, 27, 27, 27,
27, 27, 27, 27, 27, 26, 26, 27, 26, 27, 27, 26, 27, 26, 27, 27, 26, 26, 27, 26,
27, 27, 26, 28, 27, 27, 27, 27, 26, 27, 27, 26, 27, 26, 27, 27, 26, 26, 27, 27,
27, 28, 27, 26, 26, 27, 27, 27, 26, 26, 27, 26, 27, 27, 27, 27, 26, 27, 26, 26,
27, 27, 27, 26, 26, 26, 26, 27, 27, 26, 26, 27, 26, 26, 27, 26, 27, 27, 27, 27,
26, 27, 26, 26, 26, 26, 27, 27, 26, 26, 26, 26, 27, 26, 26, 26, 27, 26, 26, 26,
26, 26, 27, 27, 26, 27, 26, 26, 26, 26, 27, 26, 26, 25, 26, 27, 27, 27, 26, 27,
26, 26, 27, 26, 27, 26, 26, 26, 27, 27, 26, 26, 26, 26, 27, 26, 25, 26, 26, 26,
26, 26, 26, 26, 26, 26, 27, 26, 25, 26, 27, 25, 26, 27, 27, 27, 27, 26, 26, 26,
26, 26, 26, 26, 25, 26, 25, 26, 25, 26, 26, 26, 26, 26, 26, 26, 25, 26, 26, 26,
26, 26, 26, 25, 26, 25, 26, 26, 26, 25, 26, 25, 31, 3, -72, -117, -119, -118,
-120, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -118, -119, -118, -119,
-119, -118, -119, -118, -118, -119, -119, -119, -119, -118, -119, -119, -119,
-118, -119, -118, -119, -119, -118, -119, -118, -119, -119, -119, -117, -118,
-119, -118, -119, -118, -118, -118, -119, -119, -118, -118, -117, -118, -117,
-118, -118, -117, -118, -118, -119, -117, -118, -103, -36, 25, 30, 25, 27, 26,
28, 28, 27, 26, 27, 28, 27, 26, 28, 27, 27, 26, 28, 27, 27, 27, 28, 28, 28, 27,
28, 28, 27, 28, 28, 27, 28, 28, 28, 28, 27, 28, 27, 28, 27, 27, 27, 27, 28, 28,
28, 27, 27, 27, 27, 27, 27, 27, 28, 28, 27, 27, 28, 28, 28, 27, 27, 28, 27, 27,
27, 28, 27, 27, 26, 27, 27, 28, 27, 27, 27, 27, 27, 28, 27, 27, 27, 27, 27, 27,
27, 28, 28, 27, 28, 28, 27, 28, 27, 26, 27, 27, 28, 27, 27, 27, 27, 26, 27, 28,
28, 27, 28, 27, 27, 27, 28, 26, 28, 27, 28, 28, 27, 27, 27, 27, 28, 27, 27, 26,
27, 27, 28, 27, 27, 27, 27, 27, 27, 27, 27, 27, 25, 32, 14, -51, -107, -105,
-93, -87, -80, -74, -67, -62, -57, -51, -47, -42, -38, -34, -31, -27, -25, -21,
-18, -15, -12, -10, -8, -6, -5, -3, 0, };