#define DATA_LENGTH 512
#define DATA AKWF_1557

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 8, 10, 12, 13, 15, 16, 18,
19, 20, 20, 22, 21, 23, 23, 24, 24, 25, 25, 26, 26, 26, 26, 27, 26, 27, 27, 27,
28, 28, 28, 28, 28, 28, 29, 28, 29, 29, 28, 29, 29, 28, 29, 28, 29, 30, 29, 28,
28, 29, 28, 29, 29, 29, 29, 28, 29, 28, 29, 29, 29, 28, 28, 29, 29, 29, 29, 28,
29, 30, 29, 29, 29, 29, 29, 29, 29, 28, 29, 29, 29, 29, 29, 29, 28, 29, 29, 29,
29, 29, 29, 29, 28, 29, 29, 29, 28, 28, 29, 28, 28, 28, 28, 28, 29, 29, 28, 29,
28, 28, 28, 28, 28, 28, 29, 29, 29, 29, 28, 29, 28, 29, 28, 29, 28, 29, 28, 28,
29, 28, 28, 28, 28, 28, 28, 28, 28, 28, 29, 28, 28, 28, 29, 27, 29, 27, 29, 28,
29, 27, 28, 28, 28, 28, 28, 28, 28, 28, 27, 29, 26, 30, 26, 31, 24, 33, 21, 40,
-33, -127, -112, -122, -117, -120, -118, -119, -120, -118, -120, -119, -120,
-118, -120, -118, -119, -119, -119, -118, -119, -120, -117, -121, -117, -122,
-113, -126, -82, -67, -115, -82, -82, -66, -60, -51, -44, -37, -30, -27, -19,
-18, -11, -10, -4, -2, 2, 2, 7, 7, 11, 11, 13, 14, 17, 16, 18, 19, 21, 21, 21,
22, 23, 24, 24, 24, 24, 25, 25, 26, 25, 26, 26, 28, 26, 28, 27, 27, 27, 28, 28,
28, 28, 28, 29, 29, 29, 28, 28, 28, 29, 28, 28, 28, 29, 28, 29, 28, 29, 28, 28,
28, 28, 28, 29, 29, 28, 28, 29, 29, 28, 29, 28, 28, 29, 29, 29, 28, 28, 29, 29,
29, 28, 28, 28, 28, 29, 28, 28, 28, 29, 28, 27, 29, 28, 27, 29, 28, 28, 28, 28,
28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 27, 29, 28, 28, 27,
29, 27, 28, 28, 28, 28, 28, 28, 27, 27, 29, 28, 28, 27, 28, 28, 28, 28, 28, 27,
27, 27, 27, 28, 27, 28, 28, 28, 28, 28, 27, 28, 27, 28, 27, 29, 27, 28, 27, 27,
27, 28, 28, 27, 27, 28, 27, 27, 28, 26, 29, 27, 29, 25, 31, -42, -118, -117,
-120, -117, -119, -119, -120, -118, -119, -118, -118, -118, -119, -118, -119,
-120, -119, -119, -118, -119, -119, -119, -119, -120, -118, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -119, -118, -118, -119, -118,
-117, -119, -117, -119, -117, -120, -115, -122, -59, 28, 28, 29, 29, 29, 28, 28,
29, 29, 29, 28, 29, 28, 29, 28, 29, 29, 29, 28, 29, 28, 28, 29, 29, 28, 29, 29,
29, 29, 29, 29, 28, 29, 29, 29, 28, 29, 28, 29, 29, 29, 28, 29, 28, 29, 28, 29,
28, 29, 28, 29, 29, 28, 29, 29, 29, 28, 22, -73, -108, -83, -80, -65, -60, -50,
-44, -36, -31, -25, -21, -16, -11, -8, -4, -1, };