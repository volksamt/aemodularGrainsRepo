#define DATA_LENGTH 512
#define DATA AKWF_1512

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 6, 7, 9, 11, 12, 14, 16,
18, 20, 21, 23, 24, 26, 27, 28, 29, 31, 32, 33, 35, 37, 38, 40, 41, 42, 44, 45,
46, 47, 48, 48, 50, 50, 50, 52, 52, 53, 54, 54, 55, 56, 56, 57, 57, 58, 58, 59,
59, 59, 60, 60, 62, 62, 62, 62, 63, 64, 64, 65, 65, 65, 66, 67, 67, 68, 68, 68,
69, 69, 70, 70, 71, 71, 71, 72, 72, 73, 73, 73, 75, 75, 74, 76, 76, 76, 77, 77,
77, 77, 78, 79, 78, 79, 79, 81, 81, 82, 83, 82, 83, 83, 83, 84, 85, 85, 85, 86,
87, 87, 88, 88, 89, 88, 89, 90, 91, 92, 92, 92, 94, 94, 95, 94, 95, 96, 96, 97,
97, 98, 99, 100, 100, 100, 101, 101, 102, 102, 103, 104, 105, 105, 105, 106,
106, 107, 107, 108, 108, 109, 110, 111, 110, 111, 112, 111, 113, 113, 114, 114,
115, 115, 116, 115, 116, 116, 117, 117, 118, 117, 118, 118, 121, 112, 90, 103,
86, 103, 92, 91, 97, 91, 106, 93, 101, 94, 97, 94, 93, 91, 90, 90, 88, 88, 86,
86, 83, 83, 81, 80, 79, 79, 78, 77, 75, 74, 73, 72, 70, 69, 68, 67, 66, 65, 64,
62, 61, 60, 59, 57, 57, 54, 52, 50, 48, 46, 44, 42, 40, 39, 38, 35, 34, 33, 30,
30, 27, 25, 24, 22, 19, 18, 15, 14, 12, 11, 9, 7, 6, 5, 4, 2, 1, -1, -3, -4, -5,
-7, -8, -10, -10, -12, -15, -15, -18, -20, -22, -23, -25, -27, -29, -32, -32,
-34, -36, -38, -40, -42, -43, -44, -46, -48, -51, -52, -55, -56, -58, -58, -60,
-61, -63, -63, -64, -66, -67, -67, -69, -70, -72, -72, -74, -75, -77, -77, -80,
-80, -81, -81, -83, -84, -86, -86, -88, -87, -90, -90, -92, -93, -94, -97, -94,
-102, -93, -105, -89, -98, -90, -93, -102, -88, -104, -90, -115, -119, -118,
-119, -117, -118, -116, -117, -117, -117, -115, -117, -114, -115, -114, -113,
-113, -113, -112, -111, -111, -110, -110, -110, -109, -108, -108, -107, -108,
-106, -106, -105, -105, -104, -104, -103, -103, -101, -102, -101, -100, -101,
-100, -98, -98, -98, -97, -96, -96, -95, -95, -94, -93, -93, -92, -92, -91, -91,
-90, -90, -88, -88, -88, -88, -87, -86, -86, -85, -85, -85, -85, -83, -83, -83,
-82, -82, -81, -80, -80, -81, -80, -79, -78, -78, -78, -77, -77, -77, -75, -75,
-74, -74, -74, -74, -73, -73, -72, -71, -71, -71, -71, -70, -71, -70, -69, -69,
-68, -68, -67, -67, -66, -66, -65, -65, -64, -64, -64, -64, -63, -63, -62, -61,
-61, -60, -60, -59, -59, -58, -58, -57, -57, -56, -55, -55, -54, -54, -52, -51,
-51, -51, -50, -49, -49, -48, -47, -46, -46, -44, -42, -41, -39, -38, -36, -35,
-34, -32, -30, -30, -28, -27, -26, -24, -22, -21, -19, -17, -16, -14, -12, -10,
-9, -6, -5, -4, -3, -2, -1, };