#define DATA_LENGTH 512
#define DATA AKWF_1592

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 4, 4, 5, 6, 9, 10, 12, 13, 15,
16, 18, 20, 22, 23, 23, 23, 21, 21, 23, 28, 33, 36, 41, 46, 48, 51, 54, 56, 58,
60, 61, 64, 66, 69, 70, 72, 74, 76, 77, 77, 78, 77, 77, 78, 80, 81, 81, 81, 82,
81, 81, 80, 79, 79, 78, 77, 77, 76, 75, 74, 73, 71, 70, 69, 67, 65, 65, 63, 61,
60, 58, 54, 50, 47, 46, 47, 47, 47, 46, 46, 45, 43, 42, 40, 39, 38, 37, 37, 36,
37, 36, 38, 41, 45, 48, 48, 48, 48, 49, 50, 51, 54, 55, 57, 60, 61, 63, 65, 67,
68, 69, 70, 70, 68, 68, 67, 65, 65, 63, 62, 61, 62, 65, 70, 75, 80, 86, 90, 94,
96, 99, 100, 99, 100, 100, 98, 99, 99, 98, 98, 96, 98, 98, 97, 98, 98, 98, 99,
99, 98, 97, 96, 93, 92, 89, 87, 85, 84, 82, 81, 81, 81, 80, 82, 83, 86, 88, 90,
91, 91, 92, 95, 97, 98, 96, 93, 89, 85, 81, 78, 72, 65, 60, 59, 62, 63, 64, 63,
62, 60, 60, 58, 57, 55, 55, 54, 53, 54, 52, 53, 52, 53, 53, 52, 51, 52, 52, 51,
51, 50, 50, 50, 49, 50, 48, 48, 48, 48, 46, 47, 45, 45, 45, 44, 43, 42, 41, 41,
39, 39, 37, 36, 34, 34, 32, 32, 29, 28, 26, 24, 23, 21, 19, 17, 15, 12, 10, 7,
4, 0, -4, -8, -11, -14, -16, -17, -16, -16, -16, -16, -16, -16, -16, -15, -16,
-17, -18, -20, -22, -22, -21, -18, -16, -15, -17, -19, -21, -21, -22, -21, -22,
-21, -20, -20, -20, -20, -21, -21, -20, -22, -21, -22, -22, -22, -23, -25, -31,
-42, -49, -49, -43, -37, -36, -37, -40, -42, -43, -45, -47, -48, -50, -51, -51,
-52, -53, -53, -53, -54, -55, -56, -56, -57, -57, -57, -58, -59, -58, -59, -59,
-59, -60, -60, -62, -62, -63, -66, -67, -70, -71, -73, -74, -75, -75, -76, -78,
-79, -79, -79, -79, -80, -81, -80, -81, -81, -82, -81, -82, -83, -83, -83, -85,
-85, -85, -86, -86, -87, -88, -89, -89, -90, -91, -90, -92, -93, -94, -95, -95,
-97, -98, -98, -99, -99, -98, -97, -97, -94, -91, -88, -85, -80, -77, -75, -74,
-76, -84, -92, -102, -108, -114, -118, -119, -119, -117, -115, -113, -111, -109,
-106, -105, -104, -103, -102, -99, -96, -91, -86, -79, -71, -63, -56, -51, -45,
-41, -40, -40, -40, -41, -42, -43, -40, -37, -32, -25, -19, -14, -11, -9, -10,
-10, -12, -14, -15, -14, -13, -15, -18, -23, -26, -27, -29, -31, -31, -33, -34,
-35, -36, -37, -38, -40, -41, -43, -42, -43, -43, -43, -44, -44, -43, -44, -44,
-44, -43, -44, -43, -43, -43, -42, -41, -41, -40, -39, -38, -38, -37, -36, -36,
-35, -34, -33, -32, -31, -30, -29, -27, -26, -25, -24, -22, -21, -19, -18, -15,
-11, -7, -4, -3, -2, -1, 0, 1, };