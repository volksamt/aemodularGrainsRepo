#define DATA_LENGTH 512
#define DATA AKWF_1519

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 5, 6, 7, 8, 8, 9, 10, 11,
11, 12, 13, 14, 15, 15, 16, 18, 18, 19, 20, 21, 22, 23, 24, 25, 25, 25, 27, 28,
30, 30, 31, 32, 34, 35, 35, 36, 37, 39, 39, 40, 42, 43, 45, 46, 47, 47, 48, 50,
51, 52, 54, 54, 56, 56, 57, 59, 61, 60, 63, 64, 65, 66, 68, 68, 69, 71, 72, 74,
74, 75, 76, 76, 78, 79, 80, 82, 83, 84, 84, 86, 87, 88, 89, 89, 91, 92, 93, 94,
95, 96, 97, 98, 99, 100, 101, 101, 102, 105, 104, 106, 106, 107, 108, 109, 110,
111, 111, 112, 113, 113, 114, 115, 115, 116, 117, 118, 118, 119, 119, 119, 119,
119, 118, 119, 119, 118, 119, 119, 118, 118, 119, 117, 117, 116, 116, 115, 115,
114, 112, 112, 111, 110, 110, 109, 108, 108, 107, 106, 105, 104, 103, 102, 102,
100, 99, 98, 97, 96, 96, 94, 94, 92, 91, 90, 89, 88, 88, 87, 86, 83, 83, 82, 81,
79, 78, 77, 77, 74, 73, 73, 71, 71, 69, 67, 67, 66, 65, 64, 63, 61, 60, 60, 59,
57, 56, 54, 53, 52, 52, 50, 49, 48, 47, 46, 44, 43, 42, 41, 40, 40, 38, 37, 36,
35, 34, 32, 32, 31, 30, 28, 28, 27, 25, 25, 24, 23, 21, 22, 20, 18, 18, 17, 16,
16, 14, 15, 14, 13, 12, 10, 11, 10, 8, 8, 7, 7, 5, 4, 3, 2, 2, 0, -1, -2, -2,
-4, -5, -6, -7, -8, -8, -9, -10, -11, -11, -12, -13, -13, -15, -15, -15, -17,
-18, -19, -19, -20, -21, -22, -22, -24, -25, -26, -27, -27, -28, -30, -31, -32,
-33, -34, -34, -36, -37, -37, -39, -40, -42, -43, -43, -45, -46, -47, -47, -48,
-50, -51, -53, -54, -54, -56, -57, -58, -59, -60, -61, -62, -64, -65, -66, -67,
-68, -70, -70, -71, -73, -73, -75, -76, -77, -78, -79, -80, -82, -84, -84, -85,
-87, -87, -87, -89, -91, -91, -91, -93, -95, -95, -97, -98, -98, -100, -101,
-101, -102, -103, -103, -105, -106, -107, -108, -109, -109, -110, -111, -112,
-112, -113, -114, -115, -115, -116, -116, -116, -117, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -118, -118, -118, -117, -117,
-116, -116, -115, -114, -114, -112, -111, -111, -111, -110, -109, -108, -107,
-107, -105, -104, -104, -103, -101, -100, -100, -99, -98, -96, -95, -95, -94,
-93, -92, -90, -90, -89, -88, -86, -86, -84, -84, -82, -81, -80, -80, -78, -77,
-75, -74, -74, -72, -72, -71, -69, -68, -67, -66, -64, -63, -63, -61, -60, -59,
-57, -56, -55, -55, -53, -52, -51, -50, -48, -47, -46, -45, -44, -43, -42, -42,
-40, -39, -37, -37, -36, -34, -34, -33, -31, -30, -29, -28, -27, -26, -25, -24,
-24, -22, -22, -21, -20, -18, -18, -17, -16, -16, -14, -14, -14, -12, -11, -11,
-10, -10, -8, -8, -7, -7, -5, -4, -3, -2, -1, };