#define DATA_LENGTH 512
#define DATA AKWF_1577

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 19, 18, 18, 18, 18, 17, 17, 16,
16, 16, 16, 15, 16, 15, 15, 15, 14, 13, 14, 13, 12, 18, 43, 77, 89, 88, 87, 86,
85, 84, 84, 84, 83, 83, 81, 82, 80, 79, 79, 78, 77, 78, 76, 76, 75, 75, 75, 74,
73, 72, 72, 71, 70, 70, 68, 69, 68, 66, 67, 65, 65, 64, 65, 63, 65, 61, 64, 56,
79, 121, 118, 117, 116, 115, 115, 115, 114, 113, 112, 112, 112, 111, 111, 110,
109, 109, 108, 107, 107, 107, 107, 106, 105, 105, 104, 104, 104, 103, 102, 102,
101, 92, 64, 38, 32, 32, 32, 33, 32, 32, 33, 32, 32, 32, 31, 32, 31, 31, 31, 31,
31, 31, 31, 31, 30, 30, 31, 30, 30, 30, 30, 31, 30, 30, 30, 29, 29, 30, 30, 30,
29, 29, 29, 29, 29, 29, 29, 28, 29, 29, 29, 28, 28, 28, 29, 29, 27, 28, 29, 28,
29, 28, 28, 28, 28, 28, 28, 28, 28, 27, 28, 28, 27, 27, 28, 27, 27, 27, 27, 27,
26, 26, 27, 27, 26, 26, 26, 27, 27, 27, 27, 26, 26, 25, 26, 26, 26, 25, 26, 26,
25, 25, 26, 25, 26, 25, 25, 26, 25, 25, 25, 26, 25, 25, 25, 25, 24, 24, 25, 24,
25, 25, 25, 24, 25, 24, 24, 23, 24, 24, 24, 24, 23, 24, 24, 24, 24, 24, 23, 23,
24, 24, 24, 24, 24, 23, 24, 24, 23, 23, 22, 23, 22, 23, 23, 22, 23, 23, 23, 23,
23, 23, 23, 23, 21, 4, -31, -53, -54, -53, -53, -52, -52, -52, -50, -51, -51,
-50, -49, -50, -49, -48, -48, -48, -46, -46, -46, -46, -46, -46, -45, -44, -44,
-43, -43, -42, -42, -42, -42, -41, -41, -41, -40, -41, -40, -39, -39, -39, -38,
-37, -38, -37, -36, -37, -36, -36, -35, -36, -35, -34, -34, -34, -34, -33, -34,
-32, -32, -32, -31, -31, -32, -30, -30, -30, -30, -29, -28, -29, -29, -27, -28,
-27, -27, -27, -26, -25, -26, -25, -25, -25, -25, -25, -25, -24, -24, -23, -24,
-23, -23, -22, -22, -22, -21, -21, -21, -21, -20, -20, -20, -19, -20, -19, -19,
-18, -18, -18, -17, -16, -56, -81, -72, -75, -73, -74, -73, -74, -73, -72, -72,
-72, -71, -71, -72, -70, -71, -70, -71, -69, -70, -70, -69, -69, -69, -69, -69,
-68, -68, -67, -68, -67, -67, -67, -67, -66, -67, -65, -66, -66, -64, -65, -65,
-65, -65, -64, -64, -63, -64, -63, -63, -62, -62, -63, -63, -62, -62, -61, -62,
-61, -62, -60, -61, -60, -60, -59, -59, -60, -60, -60, -59, -59, -59, -59, -58,
-59, -58, -57, -58, -58, -58, -57, -57, -57, -57, -56, -56, -56, -56, -56, -56,
-55, -55, -55, -54, -54, -55, -54, -54, -54, -54, -53, -53, -53, -54, -54, -53,
-52, -53, -52, -52, -52, -52, -52, -52, -52, -51, -51, -51, -51, -50, -50, -51,
-51, -51, -50, -50, -50, -50, -49, -49, -36, -8, };