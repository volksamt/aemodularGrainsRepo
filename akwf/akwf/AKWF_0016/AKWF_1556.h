#define DATA_LENGTH 512
#define DATA AKWF_1556

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 5, 6, 8, 9, 11, 12, 12, 13,
15, 15, 16, 17, 18, 18, 19, 19, 20, 20, 21, 22, 22, 22, 22, 23, 23, 25, 25, 24,
25, 26, 26, 26, 26, 25, 26, 27, 26, 26, 27, 27, 27, 27, 28, 28, 27, 28, 27, 27,
28, 27, 28, 28, 29, 28, 29, 28, 29, 29, 28, 29, 29, 29, 29, 29, 29, 29, 29, 28,
29, 29, 29, 30, 30, 29, 29, 29, 28, 29, 28, 29, 29, 30, 29, 29, 28, 29, 29, 29,
29, 28, 29, 29, 29, 29, 29, 29, 29, 29, 29, 28, 30, 29, 29, 30, 29, 29, 29, 29,
29, 30, 28, 29, 29, 29, 29, 29, 29, 29, 29, 29, 29, 28, 29, 28, 29, 30, 30, 28,
28, 29, 29, 29, 29, 29, 29, 29, 29, 29, 28, 29, 29, 28, 29, 29, 28, 29, 29, 29,
29, 28, 28, 30, 29, 28, 29, 28, 29, 28, 28, 28, 29, 29, 28, 29, 29, 29, 29, 28,
29, 28, 29, 29, 29, 29, 28, 28, 28, 28, 29, 28, 29, 29, 28, 28, 29, 29, 28, 29,
29, 29, 28, 29, 29, 29, 28, 29, 28, 29, 28, 28, 28, 28, 29, 28, 29, 29, 28, 28,
29, 28, 28, 28, 28, 28, 29, 28, 28, 28, 29, 29, 27, 29, 29, 28, 28, 28, 28, 28,
29, 28, 28, 28, 28, 28, 29, 28, 29, 28, 28, 28, 28, 28, 27, 28, 29, 29, 28, 28,
28, 28, 27, 28, 27, 28, 28, 28, 28, 27, 29, 27, 29, 27, 29, 28, 28, 28, 28, 27,
28, 27, 28, 27, 28, 28, 28, 27, 28, 28, 28, 41, -55, -122, -115, -120, -117,
-121, -119, -120, -118, -120, -118, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -118, -120, -118, -119, -118, -119, -119, -118,
-119, -118, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-118, -119, -118, -118, -118, -119, -118, -119, -119, -119, -118, -118, -118,
-118, -119, -118, -118, -119, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -117, -119, -117, -118, -117, -119, -116, -119, -115, -122,
-59, 40, 30, 29, 30, 29, 30, 28, 31, 29, 31, 29, 30, 29, 31, 29, 30, 29, 30, 29,
30, 29, 29, 29, 29, 29, 29, 29, 30, 30, 29, 30, 29, 29, 29, 30, 29, 30, 30, 29,
29, 30, 30, 30, 30, 29, 29, 29, 29, 29, 29, 29, 29, 30, 30, 30, 29, 30, 30, 30,
29, 29, 30, 29, 29, 29, 29, 30, 29, 29, 29, 29, 30, 29, 29, 29, 30, 30, 29, 29,
30, 30, 30, 30, 30, 30, 29, 30, 29, 29, 29, 29, 29, 29, 29, 30, 30, 29, 29, 29,
29, 30, 30, 29, 30, 29, 29, 30, 30, 29, 30, 29, 29, 28, 28, 33, 11, -54, -109,
-105, -93, -88, -80, -74, -68, -64, -58, -54, -48, -44, -39, -36, -33, -29, -25,
-23, -20, -17, -14, -12, -10, -8, -5, -4, -2, 0, };