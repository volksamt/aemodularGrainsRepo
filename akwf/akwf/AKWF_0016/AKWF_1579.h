#define DATA_LENGTH 512
#define DATA AKWF_1579

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 6, 5, 7, 6, 7, 6, 7, 7, 7, 7, 7, 8,
8, 7, 8, 7, 8, 9, 9, 9, 21, 50, 67, 70, 68, 69, 68, 69, 67, 68, 76, 100, 117,
119, 118, 118, 118, 117, 116, 115, 115, 115, 114, 113, 113, 112, 111, 111, 111,
110, 109, 110, 109, 108, 107, 106, 107, 106, 106, 104, 104, 104, 104, 103, 103,
102, 101, 101, 100, 100, 99, 99, 98, 98, 98, 98, 97, 97, 96, 95, 95, 94, 94, 93,
93, 93, 92, 92, 92, 91, 90, 90, 90, 89, 88, 88, 88, 87, 87, 86, 86, 86, 85, 85,
84, 84, 83, 84, 83, 83, 82, 82, 81, 81, 81, 80, 79, 80, 79, 78, 78, 78, 77, 77,
77, 76, 75, 75, 74, 75, 74, 74, 74, 74, 71, 60, 35, 20, 19, 18, 19, 19, 18, 19,
19, 18, 19, 19, 18, 18, 18, 19, 18, 18, 18, 18, 18, 18, 18, 19, 19, 17, 18, 18,
18, 18, 18, 17, 17, 18, 17, 17, 18, 17, 18, 17, 17, 17, 17, 16, 17, 17, 17, 17,
17, 18, 17, 17, 17, 17, 17, 16, 17, 17, 17, 16, 17, 17, 17, 16, 16, 17, 16, 17,
16, 17, 16, 16, 16, 16, 16, 16, 16, 16, 16, 17, 17, 16, 17, 16, 15, 16, 15, 16,
16, 16, 16, 16, 16, 15, 15, 15, 15, 16, 15, 16, 15, 15, 16, 15, 16, 16, 16, 15,
15, 16, 15, 16, 15, 15, 16, 16, 15, 16, 15, 15, 15, 15, 16, 15, 15, 15, 16, 15,
15, 8, -14, -39, -46, -45, -44, -43, -44, -44, -43, -43, -43, -42, -42, -42,
-41, -40, -40, -40, -40, -40, -39, -39, -39, -38, -38, -38, -38, -37, -36, -36,
-36, -36, -36, -35, -35, -35, -35, -34, -33, -34, -34, -33, -34, -29, -41, -76,
-78, -75, -76, -75, -77, -75, -76, -74, -75, -74, -75, -74, -74, -74, -74, -73,
-72, -72, -72, -72, -72, -71, -71, -70, -71, -70, -70, -69, -70, -69, -69, -69,
-69, -68, -68, -68, -67, -68, -67, -67, -66, -66, -66, -65, -65, -65, -65, -65,
-64, -65, -64, -64, -64, -64, -62, -63, -63, -63, -62, -62, -63, -62, -62, -62,
-61, -61, -60, -61, -60, -61, -59, -59, -60, -59, -59, -58, -59, -59, -57, -59,
-59, -58, -58, -57, -57, -57, -57, -57, -56, -56, -56, -55, -55, -55, -56, -55,
-55, -54, -54, -55, -54, -53, -54, -53, -53, -53, -53, -52, -53, -53, -53, -52,
-52, -51, -52, -51, -51, -51, -51, -50, -51, -50, -50, -51, -50, -49, -50, -49,
-49, -49, -49, -49, -48, -49, -49, -49, -48, -48, -48, -48, -47, -47, -46, -47,
-47, -47, -47, -46, -46, -45, -46, -46, -46, -45, -45, -46, -45, -45, -45, -45,
-45, -44, -44, -43, -44, -43, -44, -43, -44, -43, -42, -43, -43, -43, -43, -42,
-43, -41, -42, -41, -41, -42, -42, -42, -42, -40, -40, -41, -41, -40, -40, -41,
-40, -40, -40, -40, -39, -44, -20, };