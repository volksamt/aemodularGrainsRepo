#define DATA_LENGTH 512
#define DATA AKWF_1506

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 5, 6, 6, 7, 7, 7, 8, 8, 8,
8, 8, 10, 9, 8, 8, 9, 9, 8, 8, 7, 9, 9, 9, 9, 10, 11, 11, 12, 13, 14, 14, 16,
15, 16, 17, 17, 18, 18, 18, 18, 18, 19, 18, 18, 18, 18, 17, 17, 16, 16, 17, 17,
17, 17, 18, 19, 19, 20, 21, 21, 22, 25, 25, 27, 28, 29, 30, 32, 32, 34, 35, 35,
36, 36, 36, 37, 36, 36, 37, 36, 36, 36, 35, 35, 35, 34, 35, 34, 34, 34, 36, 35,
36, 37, 38, 39, 40, 41, 43, 43, 44, 44, 46, 46, 46, 46, 47, 47, 45, 45, 44, 44,
42, 43, 41, 39, 40, 38, 38, 38, 37, 38, 38, 38, 40, 40, 42, 44, 46, 47, 50, 53,
55, 57, 59, 61, 63, 65, 66, 67, 69, 69, 70, 69, 69, 70, 69, 67, 66, 65, 65, 64,
62, 62, 61, 61, 61, 61, 61, 63, 63, 64, 66, 67, 70, 70, 73, 74, 76, 76, 78, 79,
79, 79, 78, 77, 76, 74, 72, 70, 67, 65, 62, 58, 57, 54, 52, 50, 49, 49, 48, 49,
50, 52, 55, 58, 61, 65, 69, 73, 77, 82, 86, 91, 96, 98, 102, 105, 107, 108, 109,
110, 109, 108, 107, 104, 103, 100, 98, 95, 93, 91, 89, 89, 88, 88, 88, 90, 91,
94, 98, 101, 104, 107, 111, 113, 116, 118, 119, 119, 119, 117, 116, 113, 112,
105, 93, 79, 62, 44, 27, 9, -9, -28, -45, -63, -80, -94, -106, -111, -114, -116,
-117, -119, -119, -119, -117, -117, -114, -111, -108, -103, -101, -97, -95, -91,
-90, -89, -88, -88, -89, -89, -91, -93, -96, -98, -100, -103, -105, -106, -107,
-108, -110, -109, -109, -107, -105, -102, -98, -95, -91, -86, -82, -77, -72,
-69, -64, -60, -57, -54, -51, -50, -49, -49, -48, -49, -50, -52, -55, -57, -59,
-62, -65, -67, -70, -72, -74, -76, -78, -78, -79, -79, -78, -79, -77, -76, -75,
-72, -71, -69, -68, -66, -65, -64, -63, -61, -62, -60, -61, -62, -62, -63, -63,
-64, -66, -67, -67, -68, -69, -69, -70, -68, -69, -68, -68, -65, -65, -63, -61,
-59, -56, -55, -52, -49, -47, -45, -43, -42, -41, -40, -38, -37, -38, -37, -38,
-37, -38, -40, -40, -41, -42, -43, -44, -45, -45, -46, -46, -46, -46, -46, -47,
-46, -45, -44, -43, -41, -42, -40, -40, -38, -38, -37, -35, -35, -35, -34, -35,
-34, -34, -35, -34, -35, -35, -36, -36, -36, -36, -37, -36, -37, -36, -37, -35,
-34, -33, -33, -32, -31, -29, -28, -27, -25, -23, -22, -22, -19, -20, -19, -19,
-17, -17, -16, -17, -16, -17, -17, -17, -17, -18, -18, -18, -18, -18, -19, -18,
-18, -18, -18, -18, -17, -16, -15, -15, -14, -13, -12, -12, -11, -10, -9, -9,
-9, -9, -9, -8, -8, -7, -8, -8, -8, -8, -9, -8, -9, -9, -9, -9, -8, -8, -8, -7,
-7, -5, -5, -3, -3, -2, 0, };