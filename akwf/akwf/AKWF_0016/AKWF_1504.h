#define DATA_LENGTH 512
#define DATA AKWF_1504

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 19, 33, 42, 44, 49, 52, 55, 58, 61,
64, 66, 68, 71, 73, 74, 77, 78, 80, 81, 83, 84, 87, 88, 90, 91, 93, 94, 95, 96,
98, 99, 100, 101, 103, 105, 105, 107, 107, 109, 109, 111, 111, 112, 114, 114,
115, 117, 117, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 120, 119, 119, 120, 120,
119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 120,
119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 118, 120, 118, 119, 119,
119, 119, 119, 119, 119, 119, 118, 120, 118, 120, 118, 120, 118, 121, 117, 121,
117, 111, -1, -124, -116, -120, -118, -119, -118, -120, -119, -118, -118, -116,
-116, -114, -115, -112, -112, -110, -110, -107, -108, -106, -106, -104, -103,
-102, -100, -99, -97, -96, -95, -93, -93, -91, -89, -88, -86, -85, -83, -82,
-80, -78, -77, -74, -73, -71, -68, -66, -64, -61, -58, -56, -53, -49, -45, -41,
-33, -19, -6, 7, 20, 34, 42, 46, 49, 52, 55, 59, 61, 64, 67, 68, 71, 73, 75, 77,
78, 80, 82, 83, 85, 86, 88, 89, 91, 92, 94, 96, 97, 97, 99, 99, 101, 102, 104,
105, 106, 107, 109, 110, 111, 112, 113, 113, 114, 116, 116, 117, 119, 120, 119,
120, 118, 120, 119, 120, 119, 120, 118, 120, 118, 121, 117, 121, 117, 120, 119,
42, -48, -121, -119, -118, -120, -117, -121, -118, -121, -117, -121, -118, -120,
-118, -120, -118, -120, -118, -119, -118, -119, -117, -116, -115, -114, -113,
-112, -110, -109, -109, -107, -106, -105, -104, -103, -101, -100, -99, -98, -97,
-94, -94, -92, -90, -90, -88, -87, -85, -84, -81, -80, -78, -77, -74, -72, -71,
-68, -66, -63, -61, -59, -56, -52, -49, -45, -41, -33, -19, -7, 7, 20, 33, 42,
45, 50, 53, 56, 59, 61, 63, 66, 68, 70, 73, 75, 76, 78, 80, 82, 84, 86, 86, 88,
90, 91, 92, 94, 95, 96, 98, 99, 100, 102, 103, 104, 105, 107, 108, 108, 110,
110, 112, 112, 114, 114, 116, 116, 119, 118, 119, 119, 119, 119, 119, 119, 118,
121, -11, -114, -116, -122, -118, -120, -118, -120, -119, -119, -118, -120,
-118, -119, -118, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -118, -119, -119, -120, -119, -119, -118,
-118, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -120, -120, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -120, -120, -118, -119, -119, -120, -120, -119,
-119, -118, -119, -117, -117, -115, -114, -113, -113, -112, -110, -109, -108,
-107, -106, -104, -104, -103, -102, -100, -99, -97, -96, -96, -94, -92, -91,
-89, -88, -87, -85, -83, -81, -80, -78, -76, -75, -72, -70, -69, -66, -63, -61,
-58, -55, -53, -50, -45, -40, -31, -18, -5, };