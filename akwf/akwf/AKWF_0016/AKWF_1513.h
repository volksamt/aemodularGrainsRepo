#define DATA_LENGTH 512
#define DATA AKWF_1513

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 14, 18, 21, 25, 29, 32, 36,
40, 44, 48, 51, 54, 58, 61, 64, 68, 71, 74, 77, 81, 83, 86, 89, 92, 93, 96, 99,
100, 102, 104, 106, 107, 109, 111, 112, 113, 115, 116, 116, 117, 118, 118, 119,
119, 119, 119, 119, 118, 119, 118, 117, 116, 116, 115, 114, 113, 111, 110, 108,
107, 106, 103, 102, 99, 97, 95, 93, 90, 89, 86, 83, 80, 79, 76, 73, 70, 68, 65,
62, 58, 56, 52, 50, 47, 44, 42, 38, 34, 32, 28, 26, 24, 20, 17, 14, 12, 8, 6, 3,
1, -1, -4, -6, -9, -11, -12, -15, -16, -17, -20, -21, -22, -23, -24, -25, -25,
-26, -26, -21, -13, -5, 3, 10, 17, 24, 31, 38, 43, 50, 56, 62, 69, 73, 74, 74,
74, 73, 73, 71, 70, 69, 69, 66, 65, 62, 61, 58, 56, 53, 51, 48, 46, 42, 39, 36,
34, 29, 26, 22, 19, 15, 12, 9, 6, 1, -2, -5, -9, -12, -16, -20, -23, -27, -30,
-33, -37, -40, -44, -46, -50, -53, -57, -59, -62, -66, -68, -70, -73, -75, -78,
-80, -83, -84, -87, -89, -91, -91, -93, -95, -96, -97, -99, -100, -100, -101,
-101, -101, -102, -102, -102, -102, -102, -101, -101, -101, -100, -98, -97, -97,
-95, -94, -92, -90, -89, -87, -85, -83, -81, -78, -76, -74, -71, -69, -66, -63,
-60, -56, -53, -51, -48, -44, -41, -37, -34, -30, -27, -23, -19, -16, -12, -9,
-5, -2, 1, 5, 9, 13, 17, 21, 24, 27, 31, 34, 38, 41, 44, 47, 51, 53, 57, 60, 63,
65, 69, 72, 74, 76, 78, 81, 83, 85, 87, 88, 90, 93, 93, 95, 96, 98, 99, 99, 101,
100, 101, 102, 101, 102, 102, 101, 101, 101, 100, 100, 99, 99, 97, 96, 95, 93,
93, 90, 89, 86, 84, 83, 80, 77, 76, 73, 70, 68, 65, 62, 59, 56, 53, 49, 46, 44,
40, 36, 33, 30, 26, 24, 19, 16, 12, 9, 4, 1, -2, -6, -10, -13, -16, -19, -24,
-27, -30, -34, -37, -39, -42, -45, -48, -51, -54, -56, -58, -61, -63, -65, -66,
-68, -70, -70, -72, -72, -74, -73, -74, -73, -72, -68, -62, -56, -49, -43, -37,
-30, -24, -18, -10, -2, 6, 13, 21, 27, 26, 25, 25, 25, 23, 22, 21, 20, 18, 17,
14, 13, 10, 9, 6, 3, 1, -1, -4, -6, -9, -12, -15, -17, -20, -23, -26, -29, -32,
-35, -39, -41, -44, -47, -50, -52, -56, -60, -62, -65, -68, -71, -73, -76, -79,
-82, -84, -87, -89, -91, -93, -95, -98, -100, -101, -103, -106, -107, -108,
-110, -112, -113, -114, -114, -116, -117, -117, -118, -118, -119, -119, -119,
-119, -119, -119, -118, -117, -117, -116, -115, -115, -113, -112, -111, -108,
-107, -105, -104, -102, -100, -98, -96, -93, -90, -88, -85, -83, -81, -77, -74,
-71, -67, -64, -60, -58, -54, -51, -48, -43, -40, -37, -32, -29, -24, -21, -17,
-13, -8, -5, -1, };