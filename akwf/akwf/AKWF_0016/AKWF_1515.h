#define DATA_LENGTH 512
#define DATA AKWF_1515

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 16, 20, 25, 29, 34, 38, 43,
47, 51, 55, 60, 63, 68, 71, 75, 78, 81, 86, 88, 91, 94, 97, 99, 103, 105, 107,
109, 110, 112, 113, 115, 116, 117, 118, 119, 119, 118, 119, 118, 118, 117, 116,
116, 114, 114, 112, 111, 108, 106, 105, 102, 99, 98, 94, 91, 89, 86, 82, 80, 76,
74, 70, 66, 62, 59, 56, 51, 48, 44, 41, 37, 33, 30, 26, 23, 18, 15, 11, 8, 5, 2,
-1, -4, -7, -9, -13, -15, -17, -20, -23, -24, -27, -28, -30, -31, -34, -34, -36,
-37, -39, -39, -42, -42, -42, -44, -43, -44, -45, -46, -45, -46, -46, -45, -46,
-45, -46, -45, -44, -45, -43, -43, -42, -41, -41, -39, -39, -38, -37, -36, -35,
-34, -33, -31, -30, -30, -27, -26, -25, -24, -23, -22, -20, -19, -18, -16, -16,
-15, -13, -13, -11, -10, -9, -9, -8, -7, -7, -6, -6, -5, -6, -4, -5, -5, -4, -5,
-5, -6, -6, -8, -8, -8, -10, -11, -12, -14, -15, -16, -17, -19, -21, -23, -25,
-26, -28, -31, -33, -35, -36, -39, -41, -44, -45, -48, -50, -52, -54, -55, -57,
-59, -60, -63, -64, -65, -67, -69, -70, -71, -72, -72, -73, -73, -73, -73, -73,
-73, -72, -72, -71, -71, -70, -70, -68, -68, -66, -64, -62, -61, -60, -57, -55,
-54, -53, -50, -48, -46, -44, -41, -40, -37, -35, -32, -30, -27, -24, -22, -19,
-17, -15, -12, -9, -6, -4, -1, 2, 4, 7, 9, 11, 14, 17, 20, 22, 25, 28, 29, 32,
35, 36, 40, 42, 44, 47, 49, 51, 52, 55, 57, 58, 60, 62, 62, 64, 66, 67, 69, 70,
70, 71, 71, 73, 73, 73, 73, 74, 73, 73, 73, 72, 71, 71, 70, 68, 66, 65, 63, 63,
60, 60, 58, 56, 53, 52, 49, 48, 45, 44, 41, 39, 37, 35, 33, 31, 29, 27, 26, 23,
21, 20, 18, 16, 14, 13, 12, 11, 10, 8, 7, 7, 6, 6, 6, 5, 5, 5, 5, 4, 5, 5, 5, 6,
7, 8, 8, 8, 9, 10, 11, 12, 14, 14, 17, 17, 18, 19, 21, 21, 23, 24, 25, 26, 28,
30, 30, 31, 33, 34, 35, 36, 36, 39, 38, 40, 41, 42, 43, 42, 43, 44, 44, 45, 46,
46, 45, 45, 46, 46, 46, 45, 46, 44, 44, 43, 42, 42, 42, 39, 39, 37, 37, 34, 33,
31, 29, 28, 27, 24, 22, 20, 18, 14, 13, 9, 6, 4, 1, -3, -6, -10, -12, -15, -19,
-22, -27, -31, -34, -37, -40, -45, -48, -52, -55, -59, -62, -66, -69, -73, -77,
-80, -83, -85, -90, -92, -94, -98, -100, -103, -105, -107, -108, -110, -113,
-113, -115, -116, -117, -118, -119, -118, -119, -119, -118, -118, -119, -118,
-116, -116, -114, -112, -110, -109, -106, -104, -102, -100, -98, -94, -91, -88,
-85, -81, -78, -74, -71, -67, -62, -59, -56, -51, -47, -43, -38, -33, -28, -25,
-21, -15, -11, -6, -2, };