#define DATA_LENGTH 512
#define DATA AKWF_1582

const PROGMEM int8_t DATA[DATA_LENGTH] = {52, 83, 78, 85, 87, 97, 104, 116, 110,
45, 11, 13, 6, 2, -7, -14, -24, -30, -36, -39, -41, -41, -40, -37, -37, -35,
-36, -39, -41, -45, -49, -53, -57, -59, -60, -61, -60, -60, -59, -58, -57, -57,
-56, -57, -59, -61, -61, -62, -63, -64, -64, -62, -62, -61, -60, -59, -58, -57,
-57, -57, -56, -57, -56, -57, -57, -56, -54, -53, -52, -51, -50, -49, -48, -47,
-47, -47, -46, -45, -45, -44, -43, -42, -42, -40, -39, -38, -38, -37, -36, -36,
-34, -33, -33, -33, -31, -31, -30, -29, -27, -28, -26, -25, -25, -24, -23, -22,
-21, -22, -20, -20, -19, -18, -17, -16, -15, -15, -15, -13, -12, -13, -12, -10,
-10, -9, -9, -9, -8, -6, -6, -6, -4, -5, -4, -3, -3, -2, -1, -1, 0, 0, 1, 1, 3,
3, 4, 4, 5, 5, 5, 6, 7, 7, 8, 8, 9, 9, 9, 9, 11, 11, 12, 11, 12, 13, 13, 13, 14,
14, 14, 14, 15, 16, 15, 16, 17, 17, 16, 18, 17, 18, 19, 18, 18, 18, 19, 19, 20,
20, 20, 20, 21, 22, 21, 22, 22, 22, 23, 22, 23, 23, 23, 23, 23, 24, 24, 24, 25,
24, 24, 24, 25, 25, 25, 26, 25, 25, 26, 25, 26, 26, 26, 26, 27, 26, 27, 26, 27,
27, 27, 27, 27, 27, 27, 27, 26, 27, 27, 27, 27, 27, 27, 27, 27, 27, 27, 27, 26,
27, 27, 27, 28, 28, 27, 27, 28, 27, 27, 27, 27, 27, 28, 26, 27, 27, 27, 26, 27,
27, 27, 27, 27, 27, 26, 26, 26, 26, 26, 27, 26, 25, 26, 26, 26, 26, 25, 25, 25,
25, 26, 24, 25, 24, 24, 24, 24, 24, 23, 23, 24, 23, 24, 23, 23, 23, 23, 23, 23,
23, 22, 21, 23, 22, 22, 21, 22, 22, 22, 21, 21, 20, 20, 20, 20, 21, 20, 20, 19,
19, 19, 18, 19, 19, 18, 18, 18, 18, 18, 18, 17, 16, 17, 17, 16, 16, 16, 16, 15,
15, 16, 14, 14, 15, 14, 14, 13, 14, 13, 13, 13, 13, 13, 12, 12, 12, 11, 11, 11,
11, 11, 11, 10, 10, 10, 10, 9, 8, 8, 9, 8, 9, 8, 8, 7, 8, 8, 7, 7, 6, 6, 6, 6,
5, 5, 6, 5, 5, 4, 3, 3, 3, 3, 2, 2, 3, 2, 2, 2, 2, 1, 1, 1, 0, 0, 0, -1, 0, 0,
-1, -1, -2, -1, -2, -2, -3, -3, -4, -3, -4, -4, -4, -5, -5, -6, -6, -6, -6, -7,
-6, -7, -7, -7, -7, -8, -9, -8, -9, -8, -9, -9, -10, -9, -9, -10, -11, -11, -11,
-11, -12, -12, -12, -13, -13, -13, -13, -13, -13, -14, -14, -15, -15, -15, -15,
-16, -16, -16, -17, -17, -17, -17, -17, -17, -18, -18, -19, -19, -20, -18, -20,
-20, -20, -20, -21, -20, -21, -21, -22, -22, -22, -22, -23, -23, -24, -23, -24,
-24, -25, -24, -26, -25, -25, -29, -2, };