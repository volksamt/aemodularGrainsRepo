#define DATA_LENGTH 512
#define DATA AKWF_1596

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 2, 2,
3, 3, 3, 4, 4, 5, 5, 7, 7, 8, 9, 11, 11, 12, 14, 14, 16, 16, 18, 20, 22, 23, 25,
26, 28, 29, 32, 33, 34, 36, 38, 39, 42, 44, 46, 48, 50, 52, 53, 55, 57, 60, 62,
63, 66, 67, 70, 71, 74, 76, 77, 79, 81, 82, 85, 87, 88, 90, 91, 93, 95, 97, 98,
99, 100, 101, 103, 105, 105, 107, 108, 109, 110, 111, 112, 112, 113, 113, 114,
114, 115, 115, 116, 116, 117, 118, 118, 117, 118, 118, 118, 119, 118, 119, 119,
119, 118, 119, 119, 119, 119, 118, 118, 118, 118, 117, 117, 116, 115, 115, 114,
113, 114, 112, 112, 110, 110, 110, 108, 107, 106, 106, 104, 103, 102, 100, 100,
98, 97, 96, 94, 93, 92, 90, 89, 88, 87, 85, 84, 83, 81, 79, 78, 77, 76, 75, 73,
71, 70, 70, 68, 67, 65, 63, 63, 61, 61, 60, 58, 57, 56, 54, 54, 53, 52, 51, 49,
49, 47, 46, 46, 44, 45, 44, 43, 42, 42, 41, 40, 40, 39, 39, 39, 39, 38, 38, 36,
36, 36, 36, 36, 34, 35, 34, 33, 32, 32, 32, 32, 30, 29, 29, 29, 29, 28, 27, 26,
25, 26, 25, 24, 23, 23, 22, 22, 21, 20, 20, 18, 17, 17, 17, 15, 15, 14, 13, 13,
11, 11, 10, 10, 8, 8, 7, 6, 5, 4, 4, 3, 2, 2, 1, 0, -1, -2, -3, -4, -5, -5, -6,
-7, -8, -8, -9, -10, -11, -11, -12, -13, -14, -15, -15, -16, -16, -17, -18, -18,
-20, -20, -21, -22, -22, -23, -24, -24, -26, -26, -26, -26, -28, -28, -29, -30,
-31, -31, -31, -32, -31, -32, -33, -33, -34, -35, -35, -36, -36, -36, -37, -38,
-38, -38, -39, -39, -39, -40, -40, -41, -42, -43, -43, -43, -44, -45, -45, -47,
-47, -48, -49, -50, -51, -53, -53, -54, -56, -57, -57, -59, -60, -61, -63, -63,
-64, -67, -68, -69, -70, -71, -73, -74, -75, -76, -77, -80, -81, -83, -83, -85,
-86, -89, -89, -91, -91, -94, -94, -95, -96, -98, -99, -100, -101, -103, -104,
-105, -106, -107, -107, -108, -110, -111, -112, -113, -113, -113, -115, -114,
-116, -116, -117, -117, -117, -118, -118, -117, -119, -118, -119, -118, -119,
-119, -119, -120, -119, -119, -118, -118, -117, -117, -117, -118, -117, -116,
-117, -116, -116, -114, -113, -114, -114, -112, -112, -111, -110, -109, -108,
-107, -106, -104, -103, -103, -101, -100, -98, -96, -95, -94, -92, -91, -88,
-87, -86, -84, -82, -80, -78, -75, -74, -72, -69, -68, -66, -65, -62, -60, -58,
-56, -55, -52, -50, -48, -46, -44, -43, -41, -39, -36, -35, -33, -31, -30, -28,
-27, -25, -24, -22, -20, -19, -18, -16, -15, -14, -12, -12, -11, -9, -8, -7, -8,
-6, -5, -4, -5, -3, -3, -2, -2, -2, -1, -1, -1, -1, -1, 0, -1, 0, -1, 0, 0, 1,
-1, };