#define DATA_LENGTH 512
#define DATA AKWF_1597

const PROGMEM int8_t DATA[DATA_LENGTH] = {55, 66, 61, 65, 61, 64, 62, 65, 63,
64, 63, 64, 63, 64, 62, 64, 63, 63, 62, 64, 62, 63, 63, 62, 63, 63, 63, 63, 63,
64, 63, 63, 63, 63, 63, 63, 63, 63, 62, 63, 63, 64, 63, 63, 63, 63, 63, 63, 64,
63, 63, 63, 63, 63, 63, 63, 63, 63, 63, 63, 63, 63, 63, 63, 62, 64, 63, 64, 62,
63, 63, 63, 63, 63, 63, 63, 63, 63, 63, 63, 64, 63, 63, 63, 63, 62, 63, 62, 63,
63, 63, 63, 63, 63, 63, 63, 63, 63, 64, 64, 63, 63, 62, 62, 63, 63, 64, 63, 63,
63, 63, 64, 62, 63, 63, 63, 63, 63, 62, 63, 63, 64, 63, 63, 63, 63, 63, 62, 63,
63, 64, 63, 62, 63, 63, 62, 63, 64, 63, 62, 64, 63, 63, 63, 63, 64, 64, 63, 63,
63, 63, 63, 63, 63, 64, 63, 64, 63, 62, 62, 63, 63, 63, 63, 63, 63, 62, 64, 63,
62, 63, 64, 63, 63, 63, 63, 63, 63, 63, 63, 63, 63, 64, 64, 62, 62, 63, 63, 64,
63, 63, 63, 63, 63, 64, 63, 63, 63, 63, 63, 64, 63, 63, 63, 63, 63, 63, 63, 63,
63, 62, 63, 63, 64, 61, 64, 62, 64, 62, 64, 63, 64, 63, 64, 62, 64, 61, 70, 127,
88, 49, 60, 53, 58, 55, 57, 55, 56, 56, 55, 57, 54, 57, 52, 61, 40, -4, 1, 0, 0,
0, -1, 0, -1, 1, -1, 1, -1, 1, -1, 1, -1, 0, 0, -1, 4, -44, -61, -53, -58, -55,
-56, -56, -57, -56, -55, -57, -55, -58, -54, -59, -48, -93, -127, -66, -63, -63,
-63, -63, -63, -63, -62, -64, -62, -64, -62, -64, -63, -63, -62, -63, -63, -64,
-62, -63, -63, -63, -63, -63, -63, -63, -62, -63, -63, -63, -63, -63, -63, -62,
-63, -63, -64, -63, -63, -63, -64, -64, -63, -63, -64, -64, -63, -63, -63, -64,
-63, -64, -63, -63, -63, -63, -63, -64, -63, -63, -64, -63, -63, -63, -63, -63,
-62, -63, -63, -63, -63, -63, -63, -63, -63, -63, -64, -63, -63, -63, -63, -63,
-63, -63, -63, -63, -63, -63, -62, -63, -63, -63, -63, -63, -64, -63, -64, -63,
-63, -63, -63, -63, -63, -62, -63, -63, -63, -63, -63, -63, -63, -63, -63, -63,
-63, -64, -63, -63, -63, -62, -63, -63, -63, -64, -64, -64, -63, -63, -63, -62,
-63, -63, -63, -63, -63, -62, -63, -64, -63, -64, -63, -64, -62, -63, -63, -63,
-63, -63, -63, -63, -63, -63, -63, -63, -64, -64, -64, -63, -63, -63, -63, -63,
-63, -63, -63, -62, -62, -63, -64, -63, -62, -63, -62, -63, -63, -63, -64, -63,
-64, -63, -63, -63, -63, -63, -63, -63, -64, -63, -63, -64, -64, -63, -63, -62,
-64, -63, -64, -63, -64, -63, -64, -63, -63, -63, -64, -64, -63, -62, -62, -63,
-63, -64, -62, -63, -62, -64, -62, -64, -62, -64, -62, -65, -60, -65, -60, -67,
-54, };