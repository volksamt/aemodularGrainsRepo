#define DATA_LENGTH 512
#define DATA AKWF_1594

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 13, 17, 20, 24, 27, 30, 33,
37, 41, 43, 47, 50, 54, 57, 61, 64, 67, 69, 72, 76, 78, 81, 83, 85, 87, 89, 92,
94, 96, 98, 99, 101, 104, 105, 106, 108, 109, 109, 111, 113, 112, 114, 115, 116,
116, 117, 116, 117, 119, 118, 119, 120, 120, 119, 119, 119, 119, 118, 118, 118,
119, 118, 118, 117, 117, 117, 116, 116, 115, 115, 114, 114, 113, 114, 113, 112,
111, 111, 110, 110, 109, 108, 109, 107, 107, 106, 106, 106, 106, 105, 105, 105,
105, 105, 105, 104, 105, 105, 104, 104, 103, 103, 103, 104, 103, 103, 103, 103,
104, 104, 104, 103, 104, 104, 105, 104, 104, 105, 104, 105, 104, 104, 103, 102,
100, 100, 99, 99, 98, 97, 97, 95, 94, 93, 91, 90, 89, 87, 86, 84, 83, 82, 81,
78, 78, 76, 74, 73, 72, 70, 69, 67, 66, 64, 64, 62, 61, 60, 58, 57, 56, 54, 52,
51, 49, 47, 45, 43, 41, 40, 37, 36, 34, 33, 30, 29, 27, 25, 23, 21, 20, 18, 16,
14, 13, 11, 9, 8, 6, 4, 2, 1, -1, -2, -4, -5, -7, -9, -10, -11, -12, -14, -15,
-17, -18, -19, -21, -22, -23, -24, -25, -26, -27, -28, -29, -30, -29, -30, -30,
-31, -31, -31, -31, -31, -30, -31, -30, -29, -29, -30, -29, -28, -28, -27, -26,
-25, -24, -23, -21, -19, -19, -17, -16, -14, -13, -12, -11, -8, -7, -5, -4, -1,
-1, 1, 2, 4, 5, 6, 9, 10, 11, 13, 14, 16, 18, 19, 20, 22, 23, 24, 25, 27, 26,
27, 28, 28, 30, 30, 31, 31, 31, 31, 32, 31, 31, 31, 31, 30, 30, 29, 30, 28, 27,
26, 25, 24, 24, 23, 21, 20, 19, 17, 17, 16, 14, 12, 11, 10, 8, 6, 5, 4, 2, 1,
-1, -3, -5, -6, -7, -10, -11, -13, -15, -16, -18, -20, -22, -24, -25, -27, -29,
-32, -32, -34, -36, -38, -40, -43, -44, -46, -47, -48, -50, -53, -54, -56, -58,
-58, -60, -61, -63, -63, -64, -66, -67, -69, -70, -72, -73, -75, -76, -78, -80,
-80, -83, -84, -85, -87, -88, -90, -90, -92, -92, -94, -95, -97, -97, -98, -99,
-100, -100, -100, -102, -103, -103, -104, -105, -104, -105, -105, -104, -104,
-105, -104, -104, -104, -103, -104, -103, -103, -104, -103, -103, -104, -103,
-104, -104, -104, -104, -104, -104, -105, -104, -104, -105, -104, -105, -105,
-106, -106, -107, -107, -108, -109, -109, -109, -110, -110, -111, -112, -111,
-112, -113, -113, -114, -115, -114, -115, -115, -117, -116, -117, -117, -118,
-118, -118, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -119,
-118, -117, -117, -116, -116, -115, -115, -113, -113, -112, -111, -110, -109,
-107, -106, -104, -103, -100, -99, -98, -96, -94, -92, -90, -87, -85, -83, -81,
-78, -76, -72, -70, -66, -64, -60, -58, -54, -50, -47, -44, -41, -37, -33, -29,
-27, -24, -20, -17, -13, -8, -5, -2, };