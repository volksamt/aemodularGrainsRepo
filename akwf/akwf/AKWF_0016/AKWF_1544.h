#define DATA_LENGTH 512
#define DATA AKWF_1544

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 14, 17, 20, 23, 25, 27, 29,
32, 32, 34, 35, 36, 37, 38, 40, 41, 42, 42, 42, 43, 43, 44, 44, 44, 44, 45, 46,
46, 46, 47, 46, 46, 47, 47, 46, 46, 47, 47, 47, 48, 48, 48, 48, 47, 47, 48, 48,
47, 48, 48, 48, 47, 48, 48, 48, 48, 48, 48, 48, 48, 48, 48, 48, 49, 48, 48, 48,
48, 48, 48, 48, 47, 48, 47, 48, 48, 48, 48, 47, 48, 48, 48, 48, 47, 47, 47, 48,
48, 48, 47, 48, 48, 47, 48, 48, 47, 47, 47, 48, 48, 47, 48, 48, 47, 47, 48, 46,
47, 47, 47, 47, 47, 48, 47, 47, 48, 47, 47, 48, 47, 47, 47, 47, 47, 47, 47, 46,
47, 47, 47, 46, 47, 47, 47, 47, 46, 47, 46, 46, 47, 47, 48, 47, 46, 47, 46, 46,
47, 47, 47, 47, 47, 46, 47, 47, 47, 47, 46, 47, 46, 47, 45, 47, 45, 48, 45, 47,
44, 49, 43, 56, -17, -119, -116, -119, -118, -119, -118, -119, -118, -119, -119,
-118, -119, -118, -119, -117, -119, -118, -119, -118, -119, -118, -119, -118,
-118, -119, -118, -118, -118, -118, -119, -119, -118, -118, -119, -119, -118,
-118, -117, -119, -117, -119, -117, -119, -117, -119, -116, -121, -114, -125,
-72, 43, 48, 46, 48, 46, 48, 47, 47, 47, 49, 47, 48, 47, 48, 46, 48, 47, 48, 47,
48, 47, 48, 48, 48, 46, 47, 47, 48, 47, 47, 48, 47, 47, 47, 48, 48, 47, 47, 48,
47, 47, 47, 47, 48, 48, 47, 47, 47, 47, 48, 47, 47, 47, 48, 47, 48, 46, 47, 47,
46, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47, 46, 47, 47, 47, 46, 47,
47, 47, 47, 46, 46, 47, 46, 47, 46, 47, 48, 47, 47, 46, 47, 47, 46, 47, 46, 46,
46, 47, 46, 47, 47, 47, 47, 47, 47, 46, 46, 47, 46, 46, 46, 46, 47, 46, 46, 45,
46, 46, 46, 46, 45, 46, 46, 46, 47, 46, 46, 46, 46, 45, 47, 46, 47, 46, 46, 46,
46, 45, 46, 47, 46, 46, 45, 46, 46, 45, 45, 46, 46, 45, 45, 46, 45, 45, 46, 45,
46, 45, 46, 45, 46, 46, 46, 46, 46, 45, 46, 46, 45, 45, 45, 45, 46, 44, 46, 45,
46, 44, 46, 44, 47, 43, 48, 42, 52, 5, -103, -120, -120, -120, -118, -119, -119,
-120, -119, -120, -118, -119, -118, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118,
-119, -119, -118, -119, -119, -119, -118, -118, -118, -119, -118, -119, -118,
-119, -118, -117, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-117, -118, -117, -118, -118, -118, -118, -118, -117, -118, -118, -118, -117,
-118, -117, -118, -117, -117, -117, -117, -117, -117, -117, -117, -117, -118,
-109, -95, -83, -70, -60, -49, -40, -32, -25, -19, -13, -7, -1, };