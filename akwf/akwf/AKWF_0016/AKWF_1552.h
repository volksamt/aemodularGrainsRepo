#define DATA_LENGTH 512
#define DATA AKWF_1552

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 7, 8, 9, 11, 11, 11, 12,
13, 13, 14, 15, 14, 15, 16, 16, 16, 17, 16, 17, 16, 18, 18, 18, 17, 18, 18, 18,
18, 18, 18, 18, 18, 18, 18, 19, 18, 18, 19, 19, 18, 19, 19, 18, 19, 19, 19, 19,
19, 19, 19, 18, 19, 19, 19, 19, 19, 19, 20, 19, 18, 19, 19, 19, 19, 19, 18, 19,
19, 19, 18, 19, 19, 19, 19, 19, 19, 19, 19, 19, 18, 19, 18, 19, 19, 18, 19, 19,
18, 18, 19, 18, 18, 19, 19, 19, 19, 18, 19, 18, 19, 18, 18, 19, 18, 19, 18, 19,
18, 19, 19, 18, 18, 18, 18, 18, 18, 18, 19, 19, 18, 19, 18, 18, 18, 18, 19, 19,
18, 18, 18, 19, 18, 18, 18, 19, 19, 18, 18, 18, 18, 18, 17, 18, 19, 18, 18, 19,
18, 18, 19, 18, 19, 18, 18, 18, 19, 17, 19, 17, 19, 16, 22, -48, -120, -117,
-120, -118, -120, -118, -119, -119, -119, -119, -120, -120, -119, -120, -119,
-119, -118, -119, -119, -119, -118, -120, -118, -120, -118, -119, -118, -119,
-119, -119, -118, -119, -118, -118, -118, -118, -118, -118, -119, -117, -119,
-117, -119, -118, -119, -116, -120, -116, -122, -62, 19, 18, 20, 19, 20, 19, 19,
19, 19, 20, 19, 20, 19, 20, 19, 20, 19, 20, 20, 20, 19, 20, 19, 20, 20, 19, 19,
19, 19, 19, 20, 19, 19, 20, 19, 20, 20, 20, 19, 19, 19, 20, 20, 19, 19, 20, 20,
19, 19, 19, 20, 20, 19, 19, 20, 20, 19, 19, 19, 20, 19, 19, 19, 20, 20, 19, 19,
19, 19, 19, 19, 19, 19, 20, 19, 20, 19, 19, 19, 19, 19, 19, 20, 19, 19, 20, 19,
19, 19, 19, 19, 20, 20, 19, 19, 20, 19, 19, 19, 19, 20, 19, 18, 19, 19, 19, 19,
19, 20, 19, 19, 20, 19, 19, 19, 19, 19, 18, 19, 19, 19, 19, 19, 19, 19, 19, 19,
18, 20, 19, 19, 19, 19, 19, 19, 19, 18, 24, -54, -105, -88, -82, -69, -64, -54,
-50, -42, -38, -31, -28, -23, -19, -16, -12, -10, -6, -5, -2, 0, 2, 4, 5, 6, 7,
8, 10, 11, 11, 12, 13, 13, 14, 14, 15, 15, 17, 16, 17, 17, 17, 16, 18, 18, 17,
18, 18, 19, 19, 19, 18, 18, 19, 18, 19, 19, 19, 19, 19, 19, 19, 18, 19, 18, 20,
19, 19, 20, 19, 19, 20, 19, 19, 19, 19, 19, 20, 19, 19, 19, 18, 19, 19, 19, 20,
20, 19, 20, 19, 19, 19, 20, 19, 19, 18, 19, 19, 19, 20, 19, 20, 19, 19, 19, 19,
19, 19, 19, 19, 19, 18, 20, 18, 19, 19, 18, 19, 20, 19, 19, 19, 19, 19, 20, 18,
19, 18, 19, 18, 20, 18, 20, 18, 23, -11, -103, -104, -86, -81, -68, -63, -54,
-48, -41, -36, -31, -26, -22, -19, -15, -13, -9, -7, -4, -3, 0, };