#define DATA_LENGTH 512
#define DATA AKWF_1509

const PROGMEM int8_t DATA[DATA_LENGTH] = {25, 31, 29, 30, 29, 30, 30, 31, 29,
30, 29, 30, 30, 31, 30, 29, 29, 31, 29, 30, 30, 29, 29, 29, 30, 29, 30, 28, 31,
27, 37, 62, 60, 59, 61, 58, 61, 55, 76, 93, 88, 90, 89, 89, 90, 90, 90, 89, 89,
89, 90, 89, 90, 89, 89, 89, 89, 89, 90, 89, 89, 89, 89, 89, 89, 88, 89, 89, 89,
89, 89, 90, 88, 89, 90, 89, 89, 89, 89, 89, 89, 90, 89, 89, 89, 89, 88, 92, 86,
99, 123, 117, 121, 118, 119, 119, 119, 121, 94, 88, 91, 88, 90, 88, 90, 89, 89,
89, 90, 89, 89, 89, 89, 89, 90, 89, 90, 90, 88, 90, 89, 89, 89, 90, 89, 89, 89,
89, 90, 89, 90, 89, 90, 89, 91, 89, 90, 88, 90, 89, 90, 88, 91, 89, 91, 86, 59,
59, 59, 60, 59, 61, 57, 71, 93, 89, 66, 56, 62, 58, 60, 59, 60, 58, 60, 59, 59,
59, 59, 59, 60, 59, 60, 59, 59, 61, 60, 60, 59, 60, 59, 59, 60, 60, 60, 60, 60,
59, 60, 60, 59, 59, 59, 59, 60, 59, 60, 60, 60, 59, 61, 59, 61, 57, 29, 30, 30,
29, 31, 28, 30, 29, 30, 29, 30, 29, 30, 30, 30, 30, 30, 29, 30, 30, 30, 29, 30,
30, 30, 31, 30, 30, 30, 30, 30, 30, 29, 31, 29, 30, 29, 30, 28, 32, 26, 0, 0, 1,
0, 1, 0, 1, 0, 1, -1, 0, 0, 0, -1, 0, 1, 0, 1, -1, 3, -20, -33, -27, -31, -28,
-30, -29, -31, -29, -30, -30, -31, -30, -29, -30, -30, -30, -30, -30, -30, -30,
-29, -31, -29, -30, -30, -29, -29, -30, -30, -29, -29, -30, -30, -29, -30, -30,
-29, -29, -31, -27, -51, -63, -58, -61, -58, -61, -59, -60, -59, -60, -59, -59,
-59, -60, -59, -59, -60, -59, -59, -60, -61, -59, -59, -60, -60, -59, -60, -59,
-59, -59, -59, -60, -59, -60, -60, -60, -60, -60, -59, -60, -58, -60, -58, -60,
-58, -61, -58, -61, -84, -93, -77, -57, -61, -59, -60, -59, -61, -56, -80, -93,
-88, -91, -87, -91, -88, -90, -88, -90, -89, -90, -88, -89, -89, -89, -89, -89,
-89, -89, -89, -89, -89, -89, -90, -89, -90, -89, -90, -89, -89, -90, -90, -89,
-90, -88, -90, -90, -89, -90, -88, -89, -90, -91, -90, -90, -88, -90, -116,
-122, -118, -120, -117, -122, -117, -123, -107, -87, -90, -88, -89, -89, -90,
-89, -89, -89, -90, -90, -89, -90, -89, -89, -89, -89, -89, -89, -89, -90, -89,
-89, -90, -89, -89, -89, -89, -89, -89, -90, -89, -90, -90, -89, -89, -89, -89,
-89, -89, -90, -89, -89, -90, -89, -91, -89, -91, -88, -92, -82, -57, -60, -59,
-59, -61, -59, -63, -43, -27, -32, -29, -31, -30, -30, -30, -30, -30, -29, -30,
-30, -30, -29, -30, -30, -29, -29, -29, -30, -30, -29, -30, -29, -30, -30, -30,
-30, -29, -31, -4, 1, };