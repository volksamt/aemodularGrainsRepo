#define DATA_LENGTH 512
#define DATA AKWF_1567

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 1, 2, 3, 4, 3, 4, 4, 5, 6, 5,
6, 6, 7, 7, 8, 8, 8, 9, 10, 9, 10, 10, 10, 11, 11, 11, 11, 12, 13, 13, 12, 13,
13, 13, 13, 14, 15, 15, 15, 15, 15, 15, 16, 17, 16, 17, 17, 17, 17, 18, 18, 18,
18, 18, 18, 18, 19, 19, 20, 20, 19, 20, 20, 20, 20, 19, 21, 21, 21, 21, 21, 21,
20, 22, 21, 22, 22, 21, 22, 21, 22, 23, 22, 23, 22, 22, 23, 22, 22, 23, 22, 22,
23, 23, 22, 23, 23, 23, 23, 23, 23, 23, 24, 23, 23, 23, 23, 24, 24, 23, 22, 23,
23, 24, 24, 22, 24, 23, 23, 24, 23, 22, 23, 23, 23, 23, 23, 23, 24, 22, 22, 22,
23, 22, 23, 22, 23, 23, 22, 22, 22, 22, 23, 22, 22, 22, 22, 21, 22, 21, 21, 21,
22, 22, 21, 21, 21, 21, 21, 20, 21, 20, 20, 21, 21, 21, 20, 20, 20, 20, 19, 19,
19, 20, 19, 19, 20, 19, 19, 19, 19, 18, 19, 18, 18, 17, 17, 18, 17, 16, 16, 17,
16, 17, 17, 16, 16, 17, 17, 15, 16, 16, 16, 16, 14, 15, 15, 15, 15, 14, 15, 14,
14, 13, 14, 13, 14, 13, 12, 13, 12, 12, 12, 12, 12, 12, 12, 12, 11, 11, 11, 10,
10, 10, 11, 10, 10, 9, 9, 10, 9, 8, 9, 9, 8, 8, 8, 8, 7, 7, 7, 7, 8, 7, 7, 7, 6,
6, 5, 6, 6, 6, 5, 5, 5, 5, 4, 4, 4, 4, 3, 3, 3, 3, 2, 3, 2, 2, 2, 2, 1, 1, 1, 0,
0, 1, 1, 0, -1, 0, -1, 0, -1, 0, -1, -1, -2, -2, -2, -2, -3, -3, -2, -3, -3, -3,
-4, -3, -3, -4, -3, -5, -4, -4, -6, -6, -5, -6, -5, -6, -6, -7, -7, -7, -7, -7,
-7, -8, -8, -8, -8, -9, -9, -9, -9, -10, -10, -10, -10, -11, -11, -11, -11, -10,
-11, -12, -12, -12, -12, -13, -13, -13, -13, -13, -14, -14, -14, -14, -15, -15,
-15, -15, -15, -16, -16, -15, -16, -15, -16, -17, -17, -17, -17, -17, -18, -17,
-18, -18, -18, -19, -18, -19, -18, -20, -15, -54, -104, -111, -113, -114, -116,
-116, -117, -118, -86, -43, -39, -39, -35, -31, -26, -19, -12, -6, -3, 0, 0, -3,
-7, -12, -17, -24, -26, -30, -30, -31, -29, -27, -26, -24, -23, -23, -25, -26,
-29, -31, -34, -35, -36, -37, -37, -37, -35, -34, -33, -33, -32, -31, -32, -34,
-34, -35, -35, -35, -35, -35, -34, -33, -32, -31, -30, -29, -30, -29, -28, -29,
-29, -29, -28, -27, -27, -26, -25, -25, -24, -23, -22, -22, -22, -20, -21, -21,
-20, -19, -18, -17, -18, -16, -16, -15, -15, -14, -13, -13, -11, -12, -12, -11,
-11, -10, -9, -9, -8, -7, -7, -7, -6, -5, -5, -4, -4, -4, -3, -3, -2, -1, 0, 0,
0, };