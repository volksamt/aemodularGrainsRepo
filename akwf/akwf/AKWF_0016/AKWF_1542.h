#define DATA_LENGTH 512
#define DATA AKWF_1542

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 4, 5, 6, 8, 10, 11, 14, 14, 16,
18, 20, 22, 25, 26, 27, 30, 31, 34, 37, 39, 41, 44, 46, 49, 52, 54, 57, 60, 63,
65, 68, 70, 73, 76, 79, 80, 84, 86, 89, 91, 94, 96, 97, 100, 103, 104, 106, 108,
109, 111, 112, 113, 114, 115, 116, 117, 119, 118, 119, 118, 119, 119, 119, 118,
118, 118, 118, 117, 116, 115, 113, 112, 111, 110, 108, 106, 104, 103, 101, 98,
96, 95, 92, 89, 87, 84, 82, 80, 76, 73, 71, 67, 65, 63, 59, 57, 54, 51, 48, 45,
41, 39, 36, 34, 30, 28, 24, 21, 18, 16, 13, 11, 8, 5, 2, -1, -3, -5, -8, -10,
-12, -15, -17, -19, -20, -23, -25, -26, -30, -31, -32, -35, -35, -38, -39, -41,
-43, -43, -45, -47, -47, -48, -50, -52, -52, -52, -53, -54, -56, -56, -57, -58,
-58, -58, -59, -59, -60, -60, -60, -61, -60, -60, -60, -60, -59, -59, -58, -58,
-57, -56, -56, -57, -55, -54, -53, -52, -51, -50, -49, -48, -46, -44, -44, -42,
-41, -40, -38, -37, -35, -34, -32, -29, -29, -27, -25, -23, -21, -20, -17, -15,
-13, -12, -11, -9, -6, -4, -4, -1, 0, 2, 4, 5, 6, 9, 10, 11, 13, 14, 15, 17, 18,
20, 21, 22, 24, 24, 25, 26, 27, 27, 29, 30, 29, 30, 31, 31, 32, 32, 34, 33, 34,
34, 34, 35, 34, 35, 34, 35, 33, 35, 34, 34, 33, 33, 33, 32, 31, 31, 31, 30, 30,
29, 27, 26, 25, 26, 24, 23, 22, 22, 21, 19, 19, 19, 16, 15, 14, 12, 11, 9, 8, 6,
6, 5, 2, 1, -1, -3, -4, -6, -7, -10, -12, -12, -15, -17, -18, -21, -23, -24,
-26, -28, -31, -33, -33, -36, -38, -40, -41, -43, -45, -47, -50, -52, -52, -55,
-56, -57, -60, -60, -61, -64, -64, -65, -66, -67, -68, -69, -69, -69, -70, -70,
-71, -70, -70, -70, -69, -69, -69, -67, -66, -65, -64, -63, -61, -60, -59, -56,
-55, -53, -49, -47, -45, -42, -40, -38, -35, -32, -29, -26, -22, -20, -17, -14,
-11, -9, -4, -2, 1, 4, 6, 9, 11, 13, 16, 19, 21, 22, 25, 27, 29, 30, 31, 32, 33,
34, 36, 36, 37, 37, 39, 37, 38, 38, 36, 36, 36, 35, 35, 33, 33, 30, 29, 27, 26,
24, 23, 21, 18, 16, 13, 12, 8, 6, 3, 1, -2, -5, -8, -10, -13, -17, -19, -22,
-25, -28, -31, -33, -36, -38, -41, -43, -46, -47, -50, -52, -55, -55, -57, -59,
-61, -62, -63, -65, -65, -65, -68, -68, -68, -69, -68, -69, -69, -68, -67, -68,
-68, -67, -66, -67, -65, -65, -63, -63, -61, -60, -59, -59, -57, -55, -55, -53,
-52, -50, -48, -47, -45, -44, -42, -41, -39, -38, -36, -34, -34, -32, -31, -29,
-28, -26, -24, -24, -22, -21, -20, -19, -17, -15, -15, -13, -12, -11, -10, -8,
-6, -6, -4, -3, -2, 0, };