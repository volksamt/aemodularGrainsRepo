#define DATA_LENGTH 512
#define DATA AKWF_1523

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 3, 3, 3, 5, 5, 5, 5, 7, 7,
8, 8, 9, 10, 10, 11, 11, 11, 11, 13, 13, 13, 14, 15, 16, 16, 17, 17, 17, 18, 19,
19, 20, 20, 21, 21, 22, 22, 24, 25, 24, 24, 29, 37, 46, 52, 58, 65, 72, 78, 85,
93, 97, 105, 113, 119, 119, 118, 118, 117, 117, 116, 117, 117, 116, 115, 116,
115, 115, 115, 114, 114, 114, 113, 114, 113, 112, 112, 112, 112, 111, 111, 111,
110, 110, 111, 110, 109, 109, 109, 109, 108, 107, 107, 107, 107, 107, 107, 106,
106, 105, 106, 105, 105, 105, 104, 105, 104, 104, 103, 103, 102, 102, 103, 102,
102, 101, 101, 100, 101, 101, 100, 100, 99, 99, 98, 99, 98, 98, 98, 97, 97, 97,
97, 96, 95, 96, 95, 94, 95, 95, 94, 94, 94, 93, 93, 94, 92, 92, 92, 91, 92, 91,
91, 91, 90, 90, 90, 89, 89, 90, 88, 89, 89, 88, 87, 88, 87, 87, 87, 87, 86, 85,
86, 85, 85, 85, 85, 84, 85, 85, 83, 84, 83, 83, 82, 81, 83, 82, 80, 82, 83, 78,
69, 66, 67, 68, 65, 65, 64, 64, 63, 62, 63, 61, 61, 61, 59, 59, 59, 58, 58, 56,
56, 56, 55, 55, 54, 53, 53, 52, 51, 51, 51, 49, 47, 46, 44, 42, 40, 40, 37, 35,
33, 32, 31, 29, 26, 25, 23, 21, 19, 17, 16, 15, 13, 10, 10, 7, 5, 4, 2, 1, -1,
-2, -4, -6, -7, -9, -11, -13, -14, -16, -18, -20, -21, -24, -26, -27, -28, -30,
-32, -33, -35, -37, -38, -40, -42, -44, -46, -48, -49, -51, -51, -51, -52, -53,
-53, -53, -56, -56, -56, -56, -57, -58, -58, -60, -60, -59, -60, -61, -61, -62,
-63, -63, -64, -65, -65, -65, -67, -66, -65, -69, -79, -82, -82, -80, -81, -83,
-81, -82, -84, -83, -83, -84, -84, -84, -84, -85, -85, -85, -85, -86, -86, -86,
-86, -87, -88, -87, -87, -88, -88, -89, -88, -89, -89, -90, -89, -90, -90, -91,
-91, -91, -91, -92, -92, -92, -92, -93, -93, -94, -94, -94, -94, -94, -95, -96,
-95, -95, -96, -96, -97, -96, -98, -97, -97, -97, -98, -98, -98, -99, -98, -100,
-100, -100, -100, -100, -100, -102, -100, -102, -102, -102, -102, -102, -102,
-103, -104, -103, -103, -104, -104, -105, -105, -106, -106, -106, -106, -106,
-107, -107, -107, -108, -108, -108, -109, -109, -109, -110, -110, -110, -110,
-110, -112, -112, -111, -112, -112, -111, -113, -113, -113, -114, -114, -114,
-114, -115, -115, -115, -116, -117, -117, -116, -116, -116, -117, -117, -117,
-118, -119, -118, -112, -104, -98, -92, -85, -78, -72, -66, -57, -51, -46, -38,
-29, -24, -24, -25, -22, -22, -22, -22, -20, -21, -20, -19, -19, -18, -18, -17,
-16, -16, -15, -15, -13, -14, -13, -13, -12, -11, -11, -11, -10, -10, -8, -8,
-8, -7, -6, -5, -5, -5, -4, -4, -2, -3, -3, -1, -2, -1, };