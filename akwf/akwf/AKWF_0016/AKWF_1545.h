#define DATA_LENGTH 512
#define DATA AKWF_1545

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 12, 14, 17, 18, 21, 22,
23, 24, 24, 26, 27, 28, 29, 29, 29, 30, 31, 31, 31, 32, 32, 33, 34, 34, 33, 35,
34, 33, 34, 34, 34, 35, 35, 35, 35, 36, 36, 35, 36, 35, 35, 35, 36, 35, 35, 35,
36, 36, 36, 36, 35, 36, 36, 36, 36, 35, 36, 36, 36, 35, 35, 35, 35, 35, 36, 35,
36, 36, 36, 36, 35, 36, 36, 35, 36, 36, 35, 35, 36, 35, 36, 35, 36, 36, 35, 36,
35, 36, 35, 35, 36, 36, 35, 36, 35, 36, 36, 35, 36, 35, 35, 35, 35, 35, 34, 35,
35, 35, 35, 35, 34, 35, 35, 35, 35, 35, 36, 36, 35, 36, 34, 34, 35, 35, 36, 35,
35, 34, 34, 35, 36, 35, 35, 35, 34, 35, 35, 34, 35, 35, 35, 35, 35, 35, 35, 35,
34, 34, 34, 35, 34, 35, 34, 36, 34, 36, 33, 36, 34, 36, 33, 36, 34, 35, 34, 34,
36, 30, 42, -87, -120, -100, -114, -102, -112, -105, -111, -105, -110, -106,
-110, -106, -109, -107, -108, -106, -108, -108, -107, -108, -107, -108, -107,
-107, -107, -108, -106, -108, -107, -108, -106, -108, -107, -108, -107, -108,
-106, -107, -107, -107, -107, -107, -107, -106, -108, -106, -108, -105, -110,
-5, 50, 29, 39, 32, 38, 34, 37, 35, 36, 36, 36, 36, 36, 35, 36, 36, 36, 36, 35,
36, 35, 36, 35, 36, 35, 36, 35, 36, 36, 36, 35, 36, 36, 36, 35, 35, 36, 35, 35,
35, 36, 36, 36, 35, 36, 35, 35, 35, 35, 35, 36, 35, 35, 35, 35, 35, 36, 35, 36,
35, 35, 36, 36, 35, 35, 36, 35, 35, 36, 35, 35, 36, 35, 35, 35, 35, 35, 36, 34,
35, 35, 35, 34, 35, 35, 35, 35, 35, 35, 35, 34, 35, 35, 35, 35, 35, 35, 35, 35,
35, 35, 36, 34, 35, 34, 35, 34, 34, 35, 34, 34, 35, 35, 35, 35, 35, 36, 34, 34,
34, 35, 35, 35, 35, 35, 34, 35, 35, 35, 35, 34, 35, 34, 35, 35, 34, 35, 35, 34,
34, 34, 34, 35, 34, 34, 35, 35, 35, 34, 34, 33, 34, 34, 35, 34, 35, 35, 35, 35,
34, 34, 34, 34, 33, 35, 34, 35, 34, 34, 34, 34, 33, 35, 33, 35, 33, 34, 32, 36,
33, 35, 34, 35, 33, 34, 34, 31, 46, -69, -116, -103, -111, -105, -110, -105,
-110, -106, -109, -106, -109, -107, -108, -108, -108, -107, -108, -107, -108,
-107, -107, -107, -108, -107, -107, -108, -108, -108, -108, -108, -108, -108,
-108, -108, -107, -107, -107, -107, -107, -108, -107, -107, -108, -107, -107,
-106, -106, -108, -107, -107, -106, -107, -106, -107, -107, -106, -106, -97,
-84, -73, -63, -53, -46, -38, -32, -26, -20, -15, -11, -5, -3, 2, 3, 7, 9, 13,
13, 17, 17, 21, 20, 23, 22, 26, 10, -87, -89, -69, -66, -51, -48, -36, -33, -24,
-21, -14, -11, -5, -3, };