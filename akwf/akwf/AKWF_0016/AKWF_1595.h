#define DATA_LENGTH 512
#define DATA AKWF_1595

const PROGMEM int8_t DATA[DATA_LENGTH] = {63, 76, 71, 75, 71, 74, 71, 74, 70,
74, 71, 73, 71, 74, 71, 73, 73, 72, 72, 72, 74, 68, 108, 123, 117, 121, 117,
121, 118, 119, 118, 120, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119,
120, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118,
118, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 118, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120,
119, 120, 119, 118, 119, 119, 120, 119, 118, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 120, 118, 119, 118, 120, 118, 120, 118,
120, 118, 120, 118, 120, 118, 120, 119, 120, 119, 119, 120, 117, 122, 114, 127,
34, -11, 7, -5, 4, -3, 2, -2, 1, -1, 1, -1, 1, -1, 0, 0, 0, 1, 1, 1, 0, 0, 0, 1,
0, 1, 0, 1, 1, 1, 1, 0, 0, 0, -1, 1, 0, 0, 0, -1, -1, 0, -1, 0, -1, 0, 0, 0, -1,
0, -1, 0, -1, 0, -1, -1, -1, 1, 0, 0, -1, 0, 1, -1, 1, -1, 3, -3, 3, -5, 6, -8,
13, -41, -128, -113, -122, -116, -120, -118, -119, -119, -119, -120, -118, -120,
-119, -120, -119, -120, -119, -120, -118, -120, -118, -120, -118, -119, -119,
-119, -119, -120, -119, -119, -120, -119, -119, -118, -118, -119, -120, -119,
-119, -118, -119, -118, -120, -119, -119, -119, -119, -119, -120, -119, -120,
-119, -119, -119, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -118,
-118, -119, -120, -119, -119, -120, -119, -120, -119, -119, -119, -120, -120,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -120, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -118,
-118, -119, -119, -119, -120, -119, -120, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118,
-119, -119, -119, -119, -119, -119, -120, -119, -120, -118, -120, -118, -122,
-117, -124, -104, -67, -75, -71, -72, -72, -72, -72, -71, -73, -71, -74, -72,
-74, -71, -73, -70, -74, -70, -75, -69, -77, -62, };