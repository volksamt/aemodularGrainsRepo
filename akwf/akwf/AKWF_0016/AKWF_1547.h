#define DATA_LENGTH 512
#define DATA AKWF_1547

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 5, 8, 7, 10, 10, 11, 11, 13,
13, 14, 13, 15, 14, 16, 17, 17, 17, 16, 17, 17, 17, 18, 19, 17, 18, 18, 18, 18,
19, 18, 19, 18, 19, 18, 18, 19, 19, 20, 18, 19, 19, 19, 19, 19, 19, 19, 20, 20,
18, 21, 19, 20, 19, 20, 18, 21, 18, 20, 19, 22, 6, -84, -101, -85, -79, -67,
-62, -52, -47, -39, -35, -29, -26, -20, -18, -13, -11, -8, -6, -3, -2, 0, 3, 3,
5, 7, 8, 9, 10, 10, 12, 13, 13, 13, 14, 15, 15, 15, 16, 16, 17, 17, 16, 17, 17,
17, 18, 18, 18, 18, 18, 18, 19, 18, 18, 19, 19, 18, 19, 19, 19, 18, 19, 20, 19,
19, 19, 19, 18, 20, 20, 19, 20, 19, 19, 19, 20, 19, 19, 20, 20, 19, 19, 20, 20,
19, 19, 19, 19, 20, 19, 19, 18, 20, 19, 19, 19, 19, 18, 19, 19, 19, 20, 18, 20,
20, 19, 18, 19, 18, 19, 19, 19, 19, 19, 18, 19, 20, 19, 19, 19, 19, 20, 19, 19,
18, 19, 18, 19, 19, 20, 19, 19, 19, 19, 20, 19, 19, 19, 19, 19, 19, 19, 19, 18,
19, 19, 19, 19, 19, 18, 19, 18, 19, 18, 19, 19, 20, 18, 19, 19, 19, 19, 19, 19,
19, 18, 19, 19, 19, 20, 18, 19, 18, 19, 18, 21, 17, 20, 17, 21, 16, 20, 16, 22,
15, 23, 16, -101, -121, -117, -121, -117, -121, -118, -120, -117, -120, -117,
-120, -118, -120, -118, -120, -117, -120, -118, -120, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -118, -119, -117, -119, -117, -120, -117, -120,
-117, -120, -117, -119, -117, -119, -116, -119, -117, -118, -119, -115, -126,
-5, 28, 12, 24, 16, 23, 17, 23, 17, 22, 18, 21, 19, 20, 19, 21, 19, 20, 19, 20,
20, 20, 20, 19, 20, 19, 21, 19, 21, 20, 20, 19, 20, 20, 20, 21, 20, 20, 20, 20,
20, 20, 20, 20, 20, 20, 21, 20, 19, 20, 20, 20, 19, 20, 20, 20, 20, 20, 20, 20,
20, 20, 19, 19, 20, 20, 20, 20, 20, 20, 20, 20, 19, 20, 20, 20, 20, 20, 19, 19,
20, 19, 20, 20, 19, 20, 19, 20, 20, 20, 20, 20, 20, 20, 19, 20, 20, 20, 20, 20,
20, 19, 20, 19, 19, 20, 20, 20, 19, 19, 19, 19, 20, 19, 20, 20, 20, 19, 19, 19,
19, 19, 19, 19, 20, 19, 20, 19, 20, 19, 20, 19, 19, 20, 19, 19, 20, 20, 20, 19,
20, 19, 19, 18, 19, 19, 19, 19, 19, 19, 19, 19, 19, 18, 19, 19, 19, 20, 19, 19,
19, 20, 19, 20, 19, 19, 19, 20, 18, 20, 19, 20, 19, 20, 19, 20, 19, 20, 20, 20,
19, 18, 19, 18, 21, 17, 21, 16, 24, -64, -127, -106, -101, -83, -78, -66, -61,
-52, -46, -39, -35, -30, -25, -21, -17, -15, -11, -9, -5, -3, -1, };