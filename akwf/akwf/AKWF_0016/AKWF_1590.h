#define DATA_LENGTH 512
#define DATA AKWF_1590

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 3, 4, 6, 6, 8, 9, 10, 12,
13, 14, 15, 17, 18, 20, 20, 22, 24, 24, 26, 27, 28, 31, 31, 32, 34, 36, 37, 39,
40, 42, 43, 45, 47, 48, 51, 54, 57, 59, 62, 64, 66, 68, 69, 71, 72, 74, 75, 75,
78, 79, 79, 81, 81, 83, 83, 85, 87, 87, 88, 89, 91, 90, 92, 92, 94, 94, 95, 96,
96, 97, 97, 99, 99, 99, 100, 100, 100, 99, 99, 98, 97, 96, 95, 95, 96, 95, 96,
97, 96, 98, 98, 98, 98, 98, 99, 100, 100, 101, 101, 101, 102, 102, 103, 103,
103, 103, 103, 104, 105, 104, 104, 105, 105, 105, 106, 106, 107, 108, 108, 111,
111, 112, 113, 115, 117, 117, 118, 118, 119, 120, 119, 119, 119, 119, 119, 119,
119, 118, 118, 118, 117, 118, 117, 117, 117, 115, 114, 115, 114, 113, 114, 112,
112, 112, 111, 110, 109, 109, 108, 107, 105, 104, 101, 100, 98, 96, 93, 91, 89,
88, 88, 87, 86, 84, 84, 82, 81, 81, 79, 78, 78, 76, 75, 75, 73, 73, 72, 70, 69,
69, 67, 67, 66, 65, 64, 63, 62, 60, 59, 59, 58, 57, 56, 57, 56, 56, 57, 56, 57,
57, 57, 56, 55, 55, 53, 53, 52, 51, 49, 48, 47, 45, 44, 43, 42, 41, 39, 38, 36,
35, 34, 33, 31, 30, 28, 26, 26, 24, 23, 22, 19, 18, 17, 15, 14, 11, 9, 7, 4, 1,
-2, -4, -7, -10, -12, -13, -15, -17, -20, -20, -22, -24, -25, -26, -28, -29,
-30, -32, -34, -34, -36, -37, -38, -40, -41, -42, -44, -46, -47, -47, -49, -50,
-51, -52, -53, -54, -55, -56, -56, -57, -56, -56, -56, -56, -56, -56, -57, -57,
-58, -58, -58, -60, -61, -63, -63, -64, -65, -65, -67, -68, -69, -70, -71, -72,
-74, -74, -75, -76, -76, -77, -78, -79, -81, -81, -83, -84, -85, -85, -86, -88,
-90, -91, -92, -94, -97, -99, -101, -103, -105, -106, -107, -108, -110, -109,
-111, -112, -112, -113, -113, -113, -114, -115, -115, -115, -116, -117, -116,
-117, -117, -117, -117, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -118, -118, -118, -117, -116, -115, -114, -112, -110, -109, -108, -107,
-106, -106, -106, -105, -105, -105, -104, -105, -103, -103, -103, -102, -103,
-102, -102, -101, -101, -101, -101, -100, -100, -99, -99, -98, -97, -98, -98,
-97, -96, -97, -96, -96, -96, -95, -96, -96, -97, -98, -98, -99, -99, -99, -100,
-98, -99, -99, -98, -97, -96, -96, -95, -94, -94, -93, -91, -90, -90, -89, -88,
-86, -85, -85, -84, -82, -81, -81, -79, -78, -77, -76, -75, -73, -71, -70, -68,
-67, -65, -63, -60, -58, -56, -52, -49, -48, -47, -45, -42, -42, -40, -38, -37,
-35, -34, -33, -31, -29, -28, -27, -26, -24, -22, -22, -20, -18, -18, -17, -15,
-13, -12, -10, -10, -9, -8, -6, -4, -4, -2, -2, -1, 0, 0, 0, 0, 0, 1, };