#define DATA_LENGTH 512
#define DATA AKWF_1562

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 49, 35, 36, 37, 36, 37, 36, 37,
36, 37, 36, 37, 36, 37, 36, 38, 36, 36, 36, 37, 36, 37, 37, 37, 37, 36, 36, 37,
37, 36, 37, 37, 36, 39, 40, 18, -33, -96, -106, -90, -86, -80, -75, -69, -64,
-60, -56, -51, -47, -42, -39, -36, -33, -29, -26, -23, -20, -18, -15, -12, -10,
-8, -4, -3, -1, 0, 3, 4, 5, 7, 8, 10, 11, 13, 14, 15, 16, 17, 18, 18, 20, 21,
21, 22, 22, 24, 24, 24, 25, 26, 26, 27, 28, 28, 28, 29, 29, 30, 30, 30, 31, 31,
32, 31, 31, 32, 32, 33, 33, 33, 32, 33, 34, 34, 34, 34, 34, 35, 35, 34, 35, 36,
35, 34, 35, 35, 35, 35, 36, 35, 36, 36, 35, 36, 36, 35, 35, 36, 35, 36, 36, 36,
37, 36, 36, 36, 37, 37, 37, 37, 36, 36, 37, 37, 37, 37, 36, 36, 36, 36, 36, 36,
37, 37, 36, 37, 36, 36, 36, 36, 37, 36, 37, 37, 37, 37, 37, 37, 36, 37, 36, 37,
36, 38, 36, 37, 37, 37, 37, 36, 37, 37, 36, 36, 36, 37, 37, 37, 36, 37, 37, 37,
36, 37, 37, 37, 36, 36, 37, 36, 36, 36, 36, 36, 37, 36, 37, 37, 36, 36, 36, 36,
37, 37, 37, 37, 37, 37, 36, 36, 36, 37, 36, 37, 36, 37, 37, 36, 36, 36, 35, 37,
37, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 37, 36, 36, 36,
36, 36, 36, 36, 37, 36, 36, 35, 37, 36, 36, 37, 37, 35, 36, 36, 36, 36, 36, 36,
36, 36, 36, 36, 35, 35, 36, 36, 35, 36, 36, 36, 36, 36, 36, 35, 35, 36, 35, 36,
36, 36, 36, 35, 35, 37, 36, 35, 36, 36, 35, 35, 36, 36, 35, 36, 36, 35, 35, 36,
36, 36, 35, 36, 36, 35, 36, 35, 36, 36, 35, 36, 35, 36, 36, 35, 35, 36, 36, 35,
35, 35, 36, 36, 36, 36, 36, 35, 36, 35, 35, 35, 36, 35, 35, 35, 35, 35, 36, 35,
35, 35, 36, 35, 35, 35, 36, 36, 35, 35, 35, 35, 35, 35, 36, 35, 35, 35, 35, 35,
35, 35, 35, 35, 35, 35, 36, 35, 35, 36, 35, 35, 35, 35, 35, 35, 34, 35, 35, 34,
35, 35, 35, 35, 36, 33, 38, 47, -35, -120, -117, -119, -118, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -119,
-118, -119, -118, -119, -119, -119, -119, -120, -119, -119, -118, -118, -119,
-119, -119, -118, -118, -118, -119, -120, -118, -119, -118, -119, -118, -118,
-118, -118, -119, -118, -118, -118, -118, -118, -119, -118, -118, -118, -118,
-118, -119, -118, -119, -118, -119, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117, -117, -118,
-117, -118, -118, -119, -117, -118, -118, -119, -116, -118, -116, -118, -114,
-122, -72, };