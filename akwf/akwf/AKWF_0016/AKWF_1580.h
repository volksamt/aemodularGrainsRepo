#define DATA_LENGTH 512
#define DATA AKWF_1580

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 2, 2, 3, 2, 3, 3, 4, 3, 3, 2, 4, 4,
3, 4, 4, 4, 4, 4, 5, 5, 4, 5, 5, 5, 6, 6, 5, 6, 6, 6, 5, 5, 7, 7, 6, 7, 6, 6, 6,
7, 7, 8, 7, 7, 7, 7, 7, 8, 7, 9, 7, 8, 8, 16, 45, 67, 72, 70, 70, 70, 69, 70,
69, 69, 69, 69, 68, 68, 68, 68, 67, 67, 67, 67, 66, 67, 66, 65, 65, 66, 78, 102,
118, 118, 117, 118, 118, 116, 116, 115, 115, 114, 113, 113, 113, 112, 111, 110,
110, 110, 109, 108, 108, 108, 107, 106, 106, 105, 105, 104, 104, 104, 103, 103,
103, 102, 101, 101, 100, 100, 99, 99, 98, 98, 97, 97, 96, 97, 95, 94, 94, 94,
94, 93, 93, 93, 92, 92, 92, 90, 90, 89, 89, 89, 88, 88, 88, 87, 86, 86, 86, 86,
84, 84, 84, 84, 83, 83, 83, 82, 81, 81, 81, 80, 80, 79, 79, 79, 78, 78, 78, 78,
77, 76, 76, 76, 76, 74, 75, 74, 74, 73, 73, 73, 71, 56, 30, 17, 16, 16, 16, 16,
16, 16, 16, 17, 16, 15, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16,
16, 16, 16, 16, 17, 17, 16, 15, 16, 15, 15, 15, 15, 16, 16, 15, 15, 16, 15, 14,
15, 15, 15, 15, 15, 15, 15, 16, 15, 16, 15, 15, 16, 15, 15, 14, 15, 15, 16, 15,
15, 15, 15, 14, 15, 15, 15, 15, 14, 15, 15, 15, 14, 15, 15, 15, 14, 15, 15, 15,
15, 15, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 15, 14, 15, 14,
14, 14, 14, 14, 14, 14, 10, -10, -38, -49, -48, -47, -47, -47, -47, -46, -47,
-42, -57, -92, -93, -91, -92, -91, -90, -90, -89, -89, -88, -89, -89, -88, -88,
-87, -88, -86, -87, -87, -86, -85, -86, -85, -84, -83, -83, -84, -83, -83, -82,
-82, -82, -82, -81, -81, -80, -80, -81, -79, -79, -79, -79, -79, -78, -78, -78,
-77, -77, -77, -77, -76, -76, -76, -75, -75, -75, -76, -74, -74, -74, -74, -74,
-73, -73, -72, -73, -72, -72, -71, -71, -71, -71, -71, -70, -71, -69, -70, -69,
-69, -69, -69, -69, -69, -68, -68, -67, -66, -67, -67, -66, -66, -66, -66, -65,
-66, -65, -65, -65, -64, -64, -64, -64, -64, -63, -63, -63, -62, -63, -62, -62,
-61, -61, -61, -61, -61, -60, -60, -61, -60, -60, -59, -60, -59, -59, -58, -58,
-58, -59, -58, -57, -57, -58, -56, -57, -57, -56, -56, -56, -57, -56, -55, -56,
-55, -54, -55, -55, -55, -55, -53, -53, -54, -53, -53, -53, -52, -53, -52, -53,
-52, -52, -52, -51, -52, -52, -51, -51, -51, -51, -51, -50, -50, -50, -49, -50,
-49, -49, -50, -49, -49, -49, -48, -48, -49, -48, -48, -48, -48, -48, -48, -47,
-48, -48, -47, -46, -46, -46, -47, -44, -50, -25, };