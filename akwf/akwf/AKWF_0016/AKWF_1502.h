#define DATA_LENGTH 512
#define DATA AKWF_1502

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 19, 23, 26, 28, 31, 33, 36, 37, 38,
40, 42, 44, 44, 46, 48, 49, 50, 51, 53, 54, 54, 57, 56, 57, 60, 59, 61, 62, 63,
64, 65, 66, 67, 67, 69, 70, 70, 71, 72, 73, 74, 75, 74, 76, 76, 77, 78, 80, 80,
81, 82, 81, 83, 84, 85, 85, 86, 87, 88, 88, 88, 89, 90, 90, 91, 92, 93, 93, 93,
94, 95, 95, 96, 97, 97, 99, 99, 101, 100, 101, 102, 102, 102, 103, 104, 105,
105, 107, 107, 108, 108, 108, 108, 110, 110, 111, 112, 112, 113, 113, 114, 114,
116, 114, 116, 116, 119, 116, 121, 115, 94, 80, 60, 64, 64, 65, 66, 66, 67, 68,
69, 68, 72, 70, 73, 73, 75, 74, 77, 75, 79, 77, 80, 78, 81, 81, 82, 82, 83, 85,
82, 92, 40, 6, -47, -64, -51, -60, -51, -56, -50, -53, -48, -50, -46, -47, -44,
-44, -41, -41, -38, -37, -35, -33, -31, -28, -26, -22, -17, -3, 13, 21, 23, 27,
29, 32, 34, 36, 37, 40, 40, 43, 43, 45, 47, 48, 49, 50, 52, 53, 54, 55, 57, 58,
58, 60, 60, 61, 62, 64, 65, 65, 66, 66, 68, 68, 69, 71, 71, 73, 73, 74, 74, 75,
76, 78, 77, 78, 79, 80, 81, 81, 82, 83, 85, 85, 85, 85, 88, 86, 90, 86, 92, 87,
95, 87, 98, 81, 29, -3, -54, -42, -45, -41, -40, -39, -36, -36, -31, -32, -27,
-27, -21, -20, -6, 7, 21, 22, 27, 26, 33, 31, 37, 35, 40, 40, 43, 44, 43, 52, 0,
-31, -85, -97, -87, -93, -87, -91, -86, -89, -86, -88, -84, -87, -84, -84, -81,
-82, -82, -82, -80, -79, -78, -78, -77, -76, -76, -74, -74, -72, -72, -72, -71,
-69, -68, -68, -66, -65, -64, -64, -64, -62, -61, -60, -59, -59, -57, -56, -54,
-54, -53, -51, -51, -49, -47, -46, -46, -45, -43, -41, -39, -38, -37, -33, -32,
-29, -27, -24, -20, -13, 4, 17, 22, 25, 28, 31, 33, 35, 37, 39, 40, 42, 43, 44,
47, 46, 50, 49, 53, 50, 56, 51, 59, 51, 66, 43, -8, -44, -94, -80, -86, -82,
-83, -81, -80, -80, -79, -79, -77, -78, -75, -77, -74, -75, -72, -74, -70, -71,
-68, -70, -67, -67, -65, -66, -64, -64, -63, -60, -82, -94, -117, -120, -116,
-119, -116, -117, -115, -115, -114, -115, -113, -113, -111, -112, -111, -110,
-109, -109, -109, -108, -107, -106, -106, -104, -105, -104, -104, -102, -103,
-101, -101, -101, -100, -99, -98, -98, -97, -96, -97, -95, -94, -94, -93, -92,
-92, -91, -91, -89, -89, -88, -88, -88, -86, -86, -84, -84, -83, -83, -82, -81,
-80, -79, -79, -78, -77, -76, -76, -75, -74, -74, -72, -71, -71, -70, -69, -68,
-68, -67, -66, -64, -64, -62, -62, -60, -60, -58, -58, -57, -56, -54, -54, -52,
-50, -49, -48, -47, -47, -45, -43, -41, -40, -38, -37, -34, -32, -31, -28, -26,
-23, -19, -6, };