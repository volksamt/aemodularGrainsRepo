#define DATA_LENGTH 512
#define DATA AKWF_0491

const PROGMEM int8_t DATA[DATA_LENGTH] = {-22, -56, -82, -100, -112, -118, -119,
-116, -111, -102, -94, -85, -75, -66, -57, -49, -42, -36, -28, -22, -16, -10,
-6, 0, 4, 8, 10, 13, 13, 14, 15, 16, 14, 15, 14, 12, 11, 9, 9, 8, 6, 5, 4, 3, 1,
0, -1, -1, -2, -2, -2, -2, -2, -2, -3, -3, -2, -2, -2, -1, -1, -2, -1, -1, -1,
-1, -1, 0, 1, 0, 0, -1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 4, 10, 14, 18, 19, 20, 20,
20, 18, 17, 17, 15, 14, 12, 10, 10, 7, 6, 5, 4, 2, 1, 1, 0, -1, -2, -2, -2, -2,
-2, -3, -3, -2, -2, -3, -2, -2, -2, -2, -1, -1, -1, 0, 0, 0, 0, 0, 1, 1, 0, 0,
0, 1, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 4, 9, 13, 17, 18, 19, 20, 19,
19, 17, 16, 15, 13, 12, 11, 10, 8, 6, 5, 4, 2, 2, 2, 0, -1, -1, -1, -3, -2, -2,
-2, -3, -3, -3, -3, -2, -2, -2, -2, -2, -1, 0, -1, 0, -1, 1, 0, 0, 0, 1, 1, 1,
1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 2, 7, 12, 16, 19, 20, 20, 20,
19, 19, 16, 16, 14, 13, 11, 10, 9, 6, 6, 4, 3, 2, 1, 0, -1, -1, -2, -2, -2, -3,
-2, -3, -2, -2, -2, -3, -3, -1, -2, -1, -1, -1, -1, -1, 0, 0, 0, 0, 1, 1, 0, 0,
1, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 1, 7, 12,
16, 17, 20, 20, 20, 19, 19, 18, 15, 15, 14, 11, 10, 9, 7, 5, 5, 3, 2, 0, 0, 0,
-2, -2, -3, -2, -2, -2, -3, -2, -2, -2, -2, -2, -1, -2, -1, -1, -1, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 1, 0, 3, 7, 12, 16, 18, 20, 20, 20, 20, 19, 18, 15, 15, 12,
11, 9, 7, 8, 6, 5, 3, 2, 2, 1, -1, -1, -1, -3, -2, -3, -2, -3, -3, -2, -3, -3,
-2, -1, -1, -1, -1, -1, 0, -1, 0, 0, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 1,
1, 0, 1, 0, 1, 1, 0, 0, 1, 7, 11, 16, 17, 19, 20, 19, 19, 18, 18, 15, 15, 13,
11, 10, 8, 7, 6, 5, 3, 2, 1, 0, -1, -2, -2, -1, -2, -3, -3, -3, -3, -2, -3, -2,
-2, -2, -2, -1, -1, -1, -1, -1, -1, -1, 0, 0, 0, 1, 0, 0, 1, 0, 1, 0, 0, 1, 1,
1, 1, 0, 0, 0, 1, 0, 0, 1, 0, };