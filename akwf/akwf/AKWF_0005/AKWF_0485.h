#define DATA_LENGTH 512
#define DATA AKWF_0485

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 5, 7, 9, 11, 12, 14, 16,
17, 19, 21, 23, 24, 26, 28, 29, 31, 34, 35, 38, 39, 39, 42, 44, 45, 47, 49, 50,
52, 54, 55, 56, 59, 60, 62, 63, 66, 66, 68, 69, 71, 73, 75, 75, 77, 79, 80, 82,
84, 85, 86, 87, 89, 91, 93, 93, 94, 96, 97, 99, 100, 101, 102, 103, 104, 105,
106, 107, 108, 110, 110, 111, 112, 112, 114, 114, 115, 115, 117, 116, 117, 116,
117, 117, 118, 119, 118, 118, 118, 119, 118, 119, 119, 118, 118, 119, 119, 118,
118, 118, 118, 117, 118, 118, 117, 116, 116, 115, 115, 114, 115, 114, 113, 112,
111, 111, 111, 110, 110, 108, 107, 107, 106, 105, 104, 103, 101, 101, 100, 100,
98, 97, 96, 95, 94, 92, 91, 89, 89, 87, 86, 84, 83, 81, 80, 80, 77, 76, 74, 73,
71, 70, 68, 66, 64, 63, 61, 59, 57, 55, 55, 51, 51, 49, 47, 44, 42, 41, 39, 36,
35, 33, 31, 29, 26, 25, 23, 21, 19, 17, 15, 13, 11, 8, 7, 5, 3, 1, -1, -2, -5,
-6, -8, -11, -13, -15, -16, -18, -19, -21, -23, -26, -27, -28, -30, -32, -33,
-35, -37, -38, -40, -41, -44, -45, -47, -49, -50, -52, -52, -54, -55, -57, -59,
-60, -61, -63, -65, -65, -67, -69, -70, -71, -72, -74, -74, -76, -77, -78, -79,
-80, -82, -82, -83, -84, -85, -86, -87, -87, -89, -89, -90, -91, -91, -92, -92,
-94, -93, -95, -95, -94, -95, -95, -95, -96, -96, -96, -95, -96, -96, -96, -95,
-95, -96, -95, -95, -95, -94, -94, -94, -94, -94, -93, -94, -93, -93, -91, -91,
-91, -91, -91, -90, -90, -89, -88, -88, -88, -88, -87, -86, -85, -85, -85, -84,
-83, -83, -82, -82, -81, -81, -80, -78, -79, -77, -76, -76, -74, -74, -73, -71,
-71, -70, -69, -67, -67, -66, -64, -63, -61, -61, -59, -57, -56, -55, -54, -53,
-51, -50, -48, -47, -45, -44, -43, -42, -39, -37, -37, -35, -34, -31, -31, -29,
-27, -26, -25, -23, -22, -21, -21, -19, -18, -18, -17, -16, -16, -16, -15, -15,
-14, -15, -14, -14, -14, -14, -14, -13, -14, -15, -15, -15, -15, -15, -15, -16,
-17, -16, -16, -17, -16, -18, -18, -18, -18, -19, -19, -19, -19, -19, -20, -20,
-20, -20, -20, -19, -21, -21, -21, -21, -22, -22, -22, -21, -22, -22, -22, -23,
-22, -23, -22, -23, -24, -23, -23, -23, -23, -24, -24, -23, -24, -24, -24, -25,
-24, -25, -25, -25, -25, -26, -26, -25, -26, -25, -27, -27, -26, -27, -27, -26,
-27, -27, -27, -27, -27, -28, -28, -28, -28, -28, -28, -27, -28, -28, -28, -28,
-28, -28, -28, -28, -28, -27, -27, -28, -27, -27, -26, -26, -25, -25, -25, -24,
-24, -24, -24, -23, -23, -23, -22, -21, -21, -21, -20, -19, -18, -17, -17, -17,
-15, -14, -14, -13, -12, -10, -10, -8, -7, -6, -4, -3, -2, 0, };