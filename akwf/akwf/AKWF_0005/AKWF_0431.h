#define DATA_LENGTH 512
#define DATA AKWF_0431

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 10, 9, 7, 4, 4, 4, 4, 5, 7, 7, 8,
10, 10, 11, 12, 13, 13, 13, 13, 14, 15, 15, 15, 16, 17, 18, 19, 20, 21, 22, 23,
26, 27, 29, 31, 33, 35, 37, 38, 41, 43, 44, 45, 46, 47, 48, 49, 49, 49, 50, 49,
50, 50, 49, 50, 49, 49, 48, 48, 47, 47, 47, 46, 46, 46, 45, 45, 44, 45, 45, 45,
45, 45, 46, 44, 46, 46, 46, 47, 46, 47, 47, 47, 48, 48, 49, 49, 50, 50, 51, 51,
52, 52, 52, 52, 53, 54, 55, 55, 56, 56, 57, 57, 58, 59, 60, 60, 60, 62, 62, 62,
62, 63, 65, 66, 66, 66, 67, 68, 68, 69, 70, 71, 71, 72, 72, 74, 75, 74, 76, 77,
78, 79, 79, 79, 81, 82, 82, 83, 84, 85, 86, 87, 88, 88, 89, 89, 91, 91, 92, 93,
94, 95, 96, 97, 99, 99, 101, 101, 103, 106, 107, 109, 112, 114, 117, 118, 118,
118, 118, 119, 118, 119, 119, 118, 119, 119, 117, 104, 78, 51, 39, 43, 48, 51,
50, 47, 46, 48, 47, 48, 49, 49, 49, 49, 49, 49, 48, 49, 49, 49, 50, 50, 50, 49,
50, 50, 49, 50, 48, 48, 48, 47, 45, 44, 42, 41, 40, 38, 36, 35, 32, 29, 28, 26,
24, 22, 21, 20, 19, 18, 17, 15, 15, 14, 14, 14, 13, 12, 11, 11, 9, 9, 8, 7, 5,
5, 4, 3, 5, 6, 7, 8, 7, 2, -6, -10, -9, -6, -4, -3, -4, -4, -5, -7, -7, -9, -9,
-10, -11, -11, -12, -13, -13, -14, -15, -15, -15, -16, -17, -18, -18, -19, -19,
-22, -23, -24, -26, -28, -29, -31, -33, -35, -37, -39, -41, -43, -43, -45, -46,
-47, -48, -49, -49, -50, -50, -50, -51, -50, -50, -49, -49, -49, -48, -47, -47,
-47, -46, -46, -46, -46, -45, -45, -45, -45, -45, -45, -46, -45, -45, -45, -45,
-46, -46, -46, -46, -47, -48, -47, -47, -48, -49, -48, -49, -50, -50, -50, -52,
-53, -52, -53, -53, -54, -54, -54, -55, -56, -57, -57, -58, -58, -59, -60, -61,
-62, -61, -62, -63, -64, -65, -65, -66, -67, -67, -68, -68, -70, -70, -71, -71,
-73, -73, -74, -74, -76, -76, -77, -77, -79, -79, -80, -81, -82, -82, -84, -84,
-85, -85, -86, -87, -88, -89, -90, -91, -92, -93, -93, -95, -95, -96, -98, -99,
-101, -101, -101, -104, -105, -106, -110, -111, -114, -117, -117, -118, -118,
-118, -119, -118, -118, -119, -119, -119, -119, -116, -101, -75, -48, -40, -43,
-49, -50, -48, -47, -46, -47, -48, -49, -50, -49, -49, -48, -48, -49, -48, -48,
-49, -49, -50, -49, -49, -49, -50, -50, -49, -49, -49, -49, -47, -47, -45, -44,
-44, -41, -40, -38, -36, -34, -31, -29, -27, -25, -23, -22, -21, -20, -18, -17,
-17, -16, -16, -14, -13, -13, -13, -13, -11, -10, -10, -9, -8, -7, -6, -5, -3,
-4, -5, -6, -7, -8, -7, -1, };