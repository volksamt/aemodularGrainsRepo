#define DATA_LENGTH 512
#define DATA AKWF_0409

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 4, 5, 7, 8, 10, 12, 13, 15, 16,
18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 26, 28, 28, 28, 28, 28, 28, 28, 27, 26,
26, 25, 25, 24, 23, 22, 21, 19, 19, 17, 16, 15, 14, 13, 12, 11, 10, 8, 8, 6, 6,
6, 4, 4, 3, 3, 2, 3, 1, 2, 2, 1, 1, 2, 2, 1, 3, 2, 3, 3, 3, 3, 4, 5, 6, 6, 6, 6,
8, 8, 9, 9, 9, 11, 12, 13, 13, 14, 14, 15, 15, 17, 18, 18, 19, 20, 22, 22, 22,
24, 25, 25, 26, 27, 28, 29, 30, 32, 32, 34, 34, 35, 36, 37, 38, 38, 40, 40, 41,
41, 42, 42, 43, 44, 43, 44, 44, 44, 44, 44, 44, 43, 44, 43, 42, 43, 41, 42, 41,
41, 40, 39, 38, 38, 37, 37, 36, 36, 34, 34, 33, 31, 31, 30, 30, 30, 29, 28, 28,
27, 27, 26, 27, 26, 25, 25, 25, 24, 25, 24, 24, 24, 24, 23, 25, 23, 24, 24, 24,
24, 23, 24, 25, 25, 25, 25, 25, 25, 25, 26, 26, 26, 26, 27, 26, 28, 28, 28, 28,
29, 30, 29, 30, 31, 31, 32, 32, 32, 33, 34, 34, 35, 35, 36, 36, 37, 37, 38, 38,
37, 38, 39, 39, 39, 39, 40, 39, 40, 41, 40, 40, 40, 40, 41, 40, 40, 39, 40, 39,
39, 38, 39, 37, 37, 37, 36, 36, 35, 35, 35, 35, 33, 33, 32, 32, 32, 31, 30, 30,
29, 29, 29, 27, 27, 27, 27, 26, 26, 25, 25, 25, 25, 24, 24, 23, 23, 23, 22, 23,
22, 22, 22, 22, 21, 21, 21, 21, 21, 21, 20, 20, 20, 21, 20, 20, 21, 21, 20, 21,
21, 21, 20, 20, 20, 21, 21, 21, 21, 21, 21, 22, 22, 22, 23, 23, 22, 23, 23, 23,
24, 24, 23, 23, 25, 24, 25, 24, 25, 25, 26, 25, 24, 22, 17, 9, 5, -2, -9, -15,
-21, -27, -35, -41, -47, -53, -60, -65, -71, -77, -82, -87, -91, -96, -100,
-104, -107, -109, -113, -115, -116, -118, -118, -119, -119, -118, -118, -118,
-117, -115, -114, -112, -110, -107, -106, -104, -101, -98, -97, -94, -92, -89,
-86, -85, -82, -80, -78, -76, -73, -72, -71, -69, -67, -65, -64, -62, -60, -60,
-57, -56, -54, -52, -51, -49, -47, -46, -45, -43, -40, -38, -36, -35, -33, -29,
-28, -26, -23, -22, -20, -18, -16, -13, -12, -11, -9, -8, -6, -6, -5, -4, -4,
-4, -4, -4, -4, -5, -6, -7, -8, -10, -11, -13, -14, -16, -18, -21, -23, -25,
-27, -29, -31, -34, -36, -38, -39, -42, -44, -45, -47, -48, -50, -50, -52, -52,
-53, -53, -53, -54, -53, -54, -53, -52, -51, -51, -50, -50, -49, -46, -46, -44,
-44, -41, -40, -40, -38, -37, -35, -34, -33, -31, -29, -29, -27, -26, -25, -23,
-22, -21, -19, -18, -17, -15, -14, -13, -11, -10, -9, -7, -5, -4, -2, 0, };