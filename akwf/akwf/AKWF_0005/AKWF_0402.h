#define DATA_LENGTH 512
#define DATA AKWF_0402

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 9, 14, 15, 19, 22, 24, 26, 27,
26, 26, 25, 28, 32, 34, 36, 38, 41, 48, 53, 58, 64, 66, 67, 67, 67, 70, 73, 76,
77, 80, 79, 78, 78, 80, 82, 84, 85, 85, 85, 84, 85, 86, 88, 89, 92, 92, 95, 94,
96, 96, 95, 97, 96, 96, 98, 101, 101, 102, 102, 102, 101, 101, 100, 100, 100,
99, 101, 103, 105, 106, 107, 108, 110, 109, 110, 111, 116, 118, 118, 117, 117,
116, 117, 118, 117, 116, 115, 114, 113, 113, 113, 115, 115, 115, 114, 114, 113,
113, 115, 116, 116, 115, 117, 117, 118, 118, 116, 117, 116, 117, 115, 112, 111,
110, 109, 110, 111, 110, 109, 106, 102, 101, 100, 98, 97, 97, 97, 96, 97, 99,
100, 101, 101, 100, 98, 98, 97, 99, 98, 98, 97, 97, 94, 96, 95, 97, 96, 101, 94,
101, 81, -7, -37, -55, -64, -68, -69, -68, -68, -66, -68, -66, -68, -67, -68,
-66, -66, -64, -66, -66, -69, -68, -68, -68, -69, -68, -68, -68, -67, -67, -67,
-67, -67, -69, -71, -74, -75, -74, -73, -72, -71, -73, -76, -79, -80, -82, -83,
-85, -85, -84, -83, -81, -79, -77, -76, -74, -71, -71, -71, -71, -71, -71, -71,
-71, -71, -70, -71, -72, -70, -69, -67, -67, -66, -64, -62, -62, -65, -64, -64,
-64, -63, -59, -53, -51, -46, -41, -37, -36, -35, -36, -42, -44, -46, -44, -42,
-41, -39, -37, -38, -41, -43, -42, -42, -43, -46, -46, -48, -48, -47, -44, -43,
-40, -34, -31, -30, -29, -30, -33, -33, -34, -34, -33, -31, -30, -29, -28, -27,
-25, -23, -19, -17, -16, -14, -16, -17, -21, -22, -20, -19, -21, -21, -22, -25,
-25, -26, -27, -27, -23, -20, -19, -17, -19, -20, -21, -20, -22, -26, -30, -30,
-32, -33, -34, -34, -32, -33, -34, -33, -35, -34, -35, -35, -37, -37, -40, -42,
-45, -46, -47, -50, -49, -48, -47, -47, -46, -46, -46, -47, -48, -47, -48, -48,
-51, -52, -51, -50, -50, -50, -52, -56, -58, -60, -61, -63, -64, -64, -62, -56,
-51, -49, -49, -49, -49, -49, -49, -48, -46, -43, -43, -42, -41, -39, -38, -35,
-32, -32, -31, -31, -30, -33, -33, -33, -32, -30, -30, -28, -28, -30, -27, -25,
-23, -22, -23, -22, -22, -22, -23, -26, -28, -28, -29, -28, -28, -29, -28, -27,
-29, -27, -28, -28, -27, -26, -26, -27, -28, -31, -33, -34, -36, -37, -37, -37,
-37, -36, -34, -32, -32, -31, -30, -30, -29, -31, -31, -30, -30, -31, -31, -30,
-30, -31, -29, -28, -28, -30, -31, -30, -30, -30, -29, -28, -28, -26, -24, -22,
-22, -22, -22, -23, -22, -21, -21, -21, -21, -22, -21, -23, -24, -27, -25, -22,
-21, -18, -15, -13, -10, -7, -5, -2, 1, 3, 1, -1, -1, -2, 0, 0, 1, 0, 0, -3, -3,
-2, -1, 0, 0, 0, -1, -1, 0, -6, -9, -9, -9, -8, -11, -14, -17, -14, -6, -4, -1,
};