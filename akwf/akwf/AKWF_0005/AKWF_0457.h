#define DATA_LENGTH 512
#define DATA AKWF_0457

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 40, 52, 59, 64, 66, 67, 69, 71,
72, 73, 75, 76, 77, 79, 80, 81, 81, 83, 84, 84, 84, 85, 85, 85, 85, 84, 84, 85,
84, 85, 85, 85, 85, 86, 85, 85, 86, 85, 86, 85, 85, 86, 85, 86, 86, 85, 85, 85,
86, 86, 85, 86, 86, 85, 86, 86, 86, 86, 86, 86, 88, 94, 97, 100, 102, 103, 103,
104, 105, 105, 105, 105, 106, 107, 106, 107, 108, 108, 109, 108, 108, 109, 109,
109, 109, 108, 109, 109, 109, 109, 109, 108, 109, 109, 109, 109, 109, 108, 109,
109, 109, 109, 109, 108, 108, 109, 109, 109, 109, 108, 109, 109, 109, 109, 109,
109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 110, 109, 109,
109, 109, 109, 109, 109, 109, 110, 109, 109, 109, 109, 109, 110, 109, 109, 109,
109, 109, 109, 109, 108, 109, 109, 109, 109, 109, 110, 108, 109, 109, 109, 108,
109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 110, 109, 109, 109,
109, 108, 110, 109, 109, 109, 109, 108, 109, 109, 109, 109, 109, 109, 109, 109,
109, 109, 109, 109, 108, 109, 108, 109, 108, 109, 109, 110, 108, 111, 79, 16,
-23, -48, -61, -71, -78, -83, -87, -91, -94, -98, -101, -103, -107, -108, -110,
-112, -114, -114, -114, -116, -116, -117, -117, -117, -117, -118, -118, -119,
-118, -118, -118, -118, -119, -118, -119, -118, -119, -118, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -119, -120, -119, -119, -119, -119, -118, -118, -119,
-119, -119, -118, -120, -119, -118, -118, -118, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -120, -120, -119, -119,
-119, -119, -118, -120, -118, -115, -114, -112, -111, -112, -112, -112, -113,
-111, -112, -112, -111, -110, -111, -110, -110, -110, -110, -109, -110, -109,
-109, -109, -109, -110, -110, -109, -109, -109, -109, -109, -109, -108, -110,
-109, -109, -109, -109, -110, -109, -110, -109, -109, -109, -110, -110, -109,
-108, -109, -109, -109, -109, -109, -109, -109, -110, -110, -109, -109, -109,
-109, -109, -110, -109, -109, -109, -110, -107, -102, -99, -95, -93, -93, -93,
-93, -93, -92, -92, -92, -91, -91, -90, -89, -89, -88, -87, -87, -86, -86, -86,
-86, -85, -87, -86, -86, -87, -86, -86, -86, -86, -85, -86, -85, -86, -86, -86,
-85, -86, -80, -67, -52, -40, -34, -32, -32, -31, -31, -31, -29, -27, -23, -20,
-17, -14, -11, -8, -6, -4, -4, -3, -2, -2, -2, -2, -1, -2, -1, -1, -1, -1, -1,
-1, -1, -1, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0, -1, };