#define DATA_LENGTH 512
#define DATA AKWF_0492

const PROGMEM int8_t DATA[DATA_LENGTH] = {-3, -14, -23, -33, -42, -49, -56, -63,
-68, -75, -79, -84, -88, -93, -96, -99, -103, -106, -109, -111, -112, -115,
-116, -118, -118, -118, -118, -119, -119, -118, -118, -117, -116, -116, -115,
-113, -112, -110, -108, -107, -106, -103, -101, -99, -96, -95, -92, -90, -86,
-84, -82, -79, -77, -73, -70, -68, -65, -62, -60, -56, -54, -52, -48, -45, -42,
-40, -37, -34, -32, -30, -27, -24, -21, -20, -17, -16, -13, -12, -9, -7, -5, -4,
-1, 2, 6, 9, 12, 15, 17, 19, 22, 23, 25, 27, 28, 31, 32, 33, 34, 35, 35, 37, 38,
38, 39, 39, 40, 41, 40, 40, 41, 40, 40, 41, 40, 39, 39, 39, 38, 37, 37, 36, 36,
34, 34, 33, 32, 31, 31, 30, 30, 28, 28, 27, 25, 24, 24, 22, 22, 21, 20, 19, 17,
16, 16, 15, 14, 14, 12, 11, 11, 12, 14, 14, 14, 15, 16, 16, 16, 16, 16, 16, 17,
17, 16, 16, 17, 18, 17, 17, 17, 17, 17, 17, 17, 16, 16, 16, 16, 16, 15, 15, 15,
13, 14, 13, 13, 13, 12, 12, 12, 11, 11, 10, 10, 10, 9, 9, 8, 8, 7, 7, 7, 7, 5,
6, 5, 4, 4, 4, 3, 3, 3, 2, 3, 2, 2, 1, 2, 3, 4, 5, 8, 8, 9, 10, 10, 12, 12, 13,
14, 14, 15, 15, 16, 16, 16, 16, 16, 17, 18, 18, 18, 18, 18, 18, 19, 18, 17, 18,
17, 17, 17, 17, 17, 17, 16, 15, 15, 15, 15, 15, 14, 14, 13, 13, 13, 12, 12, 12,
11, 10, 11, 9, 9, 9, 7, 9, 7, 7, 7, 6, 5, 5, 5, 4, 4, 5, 4, 4, 3, 2, 2, 2, 4, 5,
6, 7, 9, 10, 10, 11, 11, 13, 13, 13, 14, 15, 15, 16, 16, 17, 17, 17, 17, 18, 18,
19, 18, 18, 18, 18, 18, 17, 17, 17, 18, 16, 17, 16, 16, 17, 16, 15, 15, 15, 14,
14, 14, 13, 13, 12, 12, 12, 11, 11, 11, 10, 9, 9, 9, 8, 7, 7, 7, 7, 7, 5, 5, 6,
4, 5, 4, 3, 3, 2, 2, 2, 2, 2, 1, 1, 1, 0, -1, 1, 2, 4, 5, 5, 7, 8, 9, 9, 10, 11,
12, 12, 13, 14, 14, 15, 16, 16, 17, 17, 17, 17, 17, 17, 17, 18, 17, 18, 18, 18,
18, 17, 17, 18, 16, 17, 17, 16, 16, 17, 15, 15, 15, 14, 14, 14, 13, 13, 12, 13,
11, 11, 10, 10, 11, 10, 10, 8, 8, 8, 8, 7, 6, 6, 5, 5, 4, 4, 5, 7, 9, 10, 11,
11, 12, 13, 13, 14, 15, 15, 16, 16, 17, 16, 16, 17, 18, 18, 18, 18, 18, 19, 19,
19, 18, 18, 18, 18, 18, 17, 18, 17, 16, 17, 16, 15, 16, 15, 15, 14, 15, 13, 14,
13, 13, 12, 12, 12, 11, 10, 10, 9, 9, 9, 9, 8, 8, 6, 7, 6, 6, 5, 5, 3, 5, 4, };