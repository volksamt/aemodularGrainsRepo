#define DATA_LENGTH 512
#define DATA AKWF_0451

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 15, 23, 30, 37, 43, 48, 52, 56, 60,
63, 66, 69, 71, 74, 76, 79, 81, 85, 89, 93, 96, 98, 100, 102, 102, 102, 102,
102, 101, 98, 95, 92, 88, 85, 82, 81, 83, 83, 87, 89, 91, 94, 97, 99, 101, 103,
105, 106, 109, 109, 110, 111, 112, 112, 111, 111, 112, 112, 112, 113, 112, 112,
113, 115, 114, 115, 115, 115, 115, 114, 113, 113, 113, 111, 111, 110, 108, 108,
106, 104, 104, 102, 101, 101, 97, 95, 88, 79, 64, 42, 16, -8, -28, -45, -58,
-69, -78, -85, -92, -97, -102, -105, -108, -111, -112, -113, -115, -116, -117,
-116, -117, -117, -117, -117, -118, -118, -117, -118, -119, -119, -118, -119,
-120, -119, -119, -119, -119, -119, -118, -118, -117, -117, -117, -115, -114,
-114, -113, -114, -113, -113, -113, -113, -112, -112, -109, -108, -107, -105,
-102, -100, -99, -98, -98, -99, -99, -101, -103, -105, -107, -109, -110, -112,
-113, -114, -113, -114, -113, -112, -111, -109, -108, -106, -105, -102, -101,
-99, -97, -95, -93, -92, -92, -90, -90, -90, -90, -89, -89, -88, -86, -83, -80,
-77, -74, -69, -65, -60, -56, -51, -46, -42, -37, -32, -26, -21, -15, -10, -5,
1, 7, 13, 19, 25, 27, 25, 16, 0, -18, -34, -47, -57, -66, -73, -79, -85, -89,
-94, -97, -99, -101, -103, -105, -105, -105, -106, -105, -103, -102, -99, -96,
-93, -89, -81, -68, -55, -44, -34, -27, -19, -11, -4, 5, 14, 22, 29, 37, 45, 51,
58, 63, 68, 72, 76, 79, 82, 84, 87, 89, 91, 93, 95, 96, 98, 101, 103, 105, 108,
109, 111, 112, 112, 113, 113, 113, 112, 112, 110, 109, 107, 105, 102, 101, 100,
100, 101, 102, 103, 105, 106, 108, 110, 111, 112, 113, 114, 114, 115, 116, 115,
115, 116, 115, 116, 115, 115, 115, 114, 115, 115, 114, 115, 116, 116, 116, 116,
115, 115, 115, 113, 113, 112, 111, 110, 108, 108, 107, 106, 104, 103, 102, 100,
99, 95, 90, 80, 65, 43, 18, -6, -26, -42, -56, -67, -76, -83, -91, -96, -100,
-103, -106, -109, -111, -112, -113, -114, -114, -114, -114, -115, -114, -115,
-115, -115, -114, -115, -114, -115, -114, -114, -115, -115, -114, -114, -113,
-112, -112, -111, -109, -108, -107, -105, -104, -103, -102, -102, -100, -99,
-97, -97, -95, -92, -91, -86, -82, -75, -69, -63, -59, -57, -57, -58, -61, -64,
-69, -73, -77, -81, -86, -89, -91, -92, -92, -92, -90, -88, -85, -80, -76, -72,
-67, -61, -54, -48, -42, -35, -30, -25, -22, -20, -19, -19, -20, -20, -18, -15,
-11, -6, 2, 9, 17, 25, 30, 36, 40, 43, 48, 50, 52, 55, 57, 59, 61, 61, 63, 64,
65, 68, 69, 70, 70, 67, 60, 48, 28, 6, -14, -31, -45, -56, -65, -72, -79, -85,
-90, -93, -97, -100, -102, -103, -104, -104, -103, -103, -102, -99, -97, -96,
-92, -86, -76, -68, -61, -56, -51, -48, -43, -39, -34, -27, -20, -11, -3, };