#define DATA_LENGTH 512
#define DATA AKWF_0499

const PROGMEM int8_t DATA[DATA_LENGTH] = {-46, -56, -51, -55, -51, -55, -51,
-54, -52, -53, -52, -53, -53, -52, -55, -46, -101, -126, -115, -123, -117, -120,
-118, -120, -118, -120, -119, -119, -118, -119, -120, -118, -120, -118, -120,
-118, -120, -116, -121, -115, -123, -109, -51, -53, -52, -52, -54, -52, -53,
-51, -53, -51, -53, -52, -52, -52, -54, -51, -53, -52, -52, -52, -53, -52, -52,
-52, -51, -52, -53, -52, -52, -53, -52, -53, -50, -54, -50, -54, -50, -55, -49,
-58, -40, 18, 13, 15, 14, 14, 15, 14, 15, 14, 15, 14, 15, 14, 15, 14, 14, 14,
15, 14, 15, 14, 14, 14, 15, 14, 14, 15, 14, 14, 14, 15, 15, 15, 15, 15, 14, 15,
14, 15, 13, 15, 15, 14, 15, 15, 14, 14, 14, 15, 14, 14, 14, 14, 14, 14, 14, 15,
15, 14, 15, 15, 14, 15, 15, 14, 15, 14, 15, 14, 14, 14, 14, 14, 14, 14, 15, 15,
15, 14, 14, 14, 14, 14, 13, 15, 14, 15, 15, 15, 14, 14, 15, 14, 14, 14, 14, 15,
15, 13, 14, 15, 15, 15, 14, 14, 14, 14, 14, 15, 15, 14, 14, 15, 14, 14, 15, 15,
14, 15, 14, 14, 15, 14, 14, 13, 15, 14, 15, 15, 14, 15, 14, 15, 15, 14, 14, 14,
15, 15, 15, 15, 14, 14, 14, 14, 15, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14,
15, 14, 14, 15, 15, 14, 15, 14, 14, 14, 14, 14, 15, 14, 14, 14, 14, 13, 15, 14,
14, 14, 14, 14, 14, 14, 15, 14, 14, 14, 14, 14, 15, 13, 14, 14, 14, 14, 13, 15,
14, 14, 14, 14, 14, 14, 14, 14, 15, 14, 14, 14, 15, 14, 14, 15, 15, 14, 13, 14,
15, 14, 13, 13, 14, 14, 15, 15, 13, 15, 14, 14, 15, 14, 14, 15, 14, 14, 14, 14,
14, 14, 13, 14, 14, 14, 14, 14, 14, 14, 15, 14, 15, 14, 14, 14, 14, 14, 14, 14,
15, 14, 13, 14, 14, 14, 13, 14, 13, 14, 13, 13, 14, 14, 14, 14, 14, 14, 14, 14,
14, 14, 14, 14, 14, 14, 14, 14, 14, 15, 14, 14, 14, 14, 13, 13, 14, 14, 14, 14,
13, 13, 14, 14, 15, 14, 14, 14, 14, 14, 14, 13, 14, 14, 14, 14, 14, 14, 14, 13,
13, 15, 14, 14, 14, 14, 14, 14, 14, 14, 14, 13, 14, 14, 14, 13, 14, 15, 14, 14,
15, 13, 14, 14, 13, 14, 14, 13, 13, 14, 13, 14, 14, 14, 13, 14, 14, 13, 13, 14,
14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 13, 14, 14, 13, 14, 14,
13, 13, 13, 13, 14, 15, 14, 14, 14, 14, 13, 14, 13, 14, 14, 13, 14, 14, 14, 14,
14, 14, 14, 14, 13, 14, 14, 14, 13, 14, 14, 14, 13, 14, 13, 14, 14, 14, 13, 14,
13, 14, 14, 13, 14, 13, 13, 13, 15, 13, 15, 11, };