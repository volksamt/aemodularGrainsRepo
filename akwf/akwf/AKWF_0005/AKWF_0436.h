#define DATA_LENGTH 512
#define DATA AKWF_0436

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 23, 32, 38, 44, 47, 50, 52, 55,
56, 57, 58, 57, 58, 57, 58, 57, 56, 56, 55, 53, 52, 53, 51, 51, 51, 50, 50, 50,
51, 52, 53, 55, 56, 57, 59, 60, 61, 61, 63, 62, 61, 60, 58, 55, 52, 48, 44, 38,
32, 26, 19, 12, 4, -5, -13, -20, -26, -34, -39, -44, -48, -52, -55, -59, -60,
-61, -62, -62, -62, -61, -60, -59, -57, -56, -55, -53, -52, -51, -51, -51, -50,
-51, -51, -52, -52, -53, -54, -55, -56, -56, -58, -58, -58, -57, -58, -58, -57,
-55, -55, -52, -50, -46, -42, -38, -31, -24, -14, -2, 4, 7, 9, 12, 14, 17, 21,
23, 27, 30, 32, 34, 37, 39, 43, 45, 47, 50, 52, 53, 56, 59, 61, 63, 66, 67, 70,
71, 74, 75, 78, 80, 82, 83, 84, 86, 89, 91, 92, 93, 95, 97, 98, 99, 100, 101,
103, 105, 105, 106, 107, 109, 110, 110, 112, 112, 112, 113, 114, 115, 116, 116,
117, 117, 117, 117, 119, 118, 119, 119, 118, 120, 120, 119, 119, 118, 119, 119,
118, 119, 117, 118, 117, 117, 116, 116, 114, 114, 113, 112, 112, 111, 110, 109,
107, 107, 106, 106, 103, 102, 101, 99, 99, 96, 96, 94, 93, 91, 90, 88, 87, 84,
82, 81, 79, 76, 75, 73, 71, 69, 67, 64, 63, 60, 57, 56, 54, 52, 48, 45, 44, 42,
39, 35, 34, 31, 28, 25, 22, 20, 17, 14, 12, 9, 5, 2, -4, -14, -24, -33, -40,
-44, -48, -51, -53, -55, -56, -57, -58, -58, -58, -57, -57, -57, -56, -56, -55,
-53, -53, -53, -51, -51, -51, -51, -50, -51, -51, -52, -53, -55, -56, -58, -59,
-60, -61, -63, -63, -62, -61, -60, -58, -55, -52, -48, -43, -37, -32, -25, -18,
-10, -4, 5, 12, 21, 27, 34, 40, 45, 49, 53, 56, 58, 61, 62, 62, 63, 62, 61, 60,
59, 57, 56, 55, 53, 53, 51, 50, 50, 50, 51, 51, 52, 53, 54, 55, 55, 56, 57, 57,
58, 58, 59, 58, 57, 57, 56, 54, 52, 50, 47, 42, 38, 30, 22, 11, 1, -5, -8, -9,
-12, -14, -18, -21, -23, -26, -29, -32, -35, -38, -40, -43, -45, -47, -50, -52,
-55, -57, -58, -61, -63, -66, -67, -70, -72, -74, -76, -77, -80, -81, -83, -85,
-87, -88, -91, -91, -93, -94, -96, -98, -99, -101, -102, -103, -104, -105, -107,
-107, -108, -109, -111, -111, -112, -113, -114, -114, -114, -116, -116, -116,
-118, -117, -117, -118, -118, -118, -119, -119, -118, -119, -119, -119, -119,
-118, -118, -117, -118, -118, -116, -117, -116, -116, -115, -114, -114, -113,
-112, -112, -111, -110, -110, -108, -107, -106, -105, -103, -102, -101, -100,
-98, -96, -96, -94, -93, -91, -90, -88, -87, -84, -82, -80, -78, -77, -75, -73,
-71, -69, -67, -64, -62, -59, -58, -56, -54, -50, -48, -46, -44, -41, -39, -36,
-33, -31, -27, -25, -23, -20, -17, -14, -11, -7, -5, -2, };