#define DATA_LENGTH 512
#define DATA AKWF_0486

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 5, 7, 7, 9, 9, 10, 11,
12, 12, 14, 15, 15, 16, 18, 18, 18, 21, 20, 21, 23, 23, 25, 25, 26, 27, 28, 28,
30, 31, 31, 31, 33, 34, 34, 34, 36, 37, 38, 39, 39, 39, 40, 41, 41, 42, 43, 44,
45, 45, 46, 47, 47, 49, 48, 48, 50, 51, 51, 51, 53, 53, 54, 54, 55, 55, 56, 56,
58, 57, 59, 59, 59, 60, 61, 61, 62, 63, 62, 63, 64, 65, 65, 65, 65, 66, 67, 67,
68, 68, 68, 69, 69, 70, 70, 71, 70, 71, 73, 72, 73, 73, 75, 75, 75, 75, 76, 75,
75, 76, 76, 78, 78, 78, 79, 78, 79, 79, 80, 80, 80, 81, 80, 81, 82, 82, 82, 83,
83, 83, 83, 84, 84, 85, 85, 85, 85, 85, 85, 87, 87, 87, 87, 86, 88, 88, 88, 88,
89, 88, 89, 89, 90, 89, 91, 90, 91, 90, 91, 92, 91, 92, 91, 92, 92, 93, 92, 93,
92, 94, 92, 95, 92, 97, 92, 96, 92, 97, 93, 97, 93, 98, 95, 96, 97, 94, 104,
-73, -113, -93, -108, -95, -105, -96, -104, -96, -102, -97, -101, -98, -100,
-97, -98, -98, -99, -97, -98, -98, -97, -97, -96, -96, -95, -97, -95, -96, -94,
-95, -94, -94, -93, -94, -94, -93, -93, -93, -92, -92, -91, -92, -91, -90, -90,
-90, -90, -89, -89, -88, -87, -88, -88, -86, -87, -86, -86, -85, -86, -85, -85,
-84, -84, -84, -83, -83, -83, -82, -82, -81, -81, -80, -81, -80, -79, -79, -79,
-77, -77, -76, -76, -75, -75, -75, -75, -74, -74, -73, -72, -72, -72, -70, -71,
-70, -70, -69, -68, -68, -67, -67, -66, -66, -65, -65, -63, -63, -62, -62, -61,
-60, -60, -60, -59, -58, -57, -57, -57, -55, -55, -54, -53, -52, -51, -51, -50,
-49, -49, -48, -47, -46, -46, -44, -44, -43, -42, -41, -40, -40, -39, -39, -37,
-36, -36, -35, -34, -33, -32, -31, -30, -29, -28, -27, -26, -25, -24, -24, -22,
-21, -20, -19, -18, -17, -16, -15, -14, -12, -11, -10, -10, -9, -7, -6, -5, -3,
-2, -1, 0, 1, 3, 4, 4, 7, 8, 9, 10, 11, 13, 14, 16, 17, 18, 19, 20, 22, 24, 25,
25, 28, 29, 30, 32, 33, 36, 36, 38, 39, 41, 42, 44, 46, 47, 48, 50, 52, 53, 54,
57, 58, 59, 61, 63, 63, 66, 68, 70, 71, 73, 73, 75, 77, 79, 81, 82, 85, 86, 89,
88, 92, 91, 95, 94, 99, 97, 103, 100, 106, 104, 110, 105, 114, 108, 117, 112,
120, 114, -72, -90, -77, -85, -75, -81, -72, -78, -70, -73, -67, -70, -64, -66,
-61, -63, -59, -59, -57, -56, -54, -53, -52, -50, -49, -47, -46, -44, -44, -42,
-41, -39, -39, -36, -35, -33, -34, -31, -31, -29, -28, -26, -25, -24, -22, -21,
-21, -20, -18, -17, -16, -15, -14, -13, -12, -10, -9, -8, -8, -5, -5, -4, -3,
-2, -1, };