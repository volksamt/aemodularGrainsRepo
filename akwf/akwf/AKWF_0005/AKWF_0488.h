#define DATA_LENGTH 512
#define DATA AKWF_0488

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 8, 9, 11, 12, 12, 14, 13,
15, 14, 14, 14, 14, 15, 13, 13, 12, 11, 10, 9, 8, 7, 5, 4, 3, 1, 0, -2, -2, -3,
-5, -6, -7, -8, -9, -9, -11, -10, -12, -12, -12, -11, -11, -11, -10, -10, -9,
-8, -7, -6, -4, -3, -1, 0, 3, 4, 6, 8, 9, 11, 13, 16, 18, 20, 22, 23, 26, 27,
29, 30, 32, 34, 36, 37, 38, 40, 40, 41, 42, 43, 44, 45, 45, 45, 45, 45, 45, 45,
45, 46, 45, 45, 44, 45, 44, 44, 44, 44, 43, 43, 43, 43, 43, 43, 42, 43, 43, 42,
42, 43, 43, 44, 45, 44, 46, 46, 47, 49, 49, 51, 52, 54, 54, 56, 56, 58, 16, -17,
20, 27, 13, 24, 26, 14, 7, -2, -15, -24, -30, -35, -38, -39, -42, -46, -50, -57,
-62, -69, -73, -77, -79, -81, -82, -82, -83, -83, -85, -85, -85, -86, -83, -83,
-80, -76, -74, -70, -67, -64, -60, -56, -52, -47, -42, -38, -33, -29, -23, -19,
-13, -9, -5, 0, 5, 7, 13, 16, 19, 23, 26, 29, 31, 32, 35, 36, 37, 38, 38, 39,
39, 39, 38, 38, 37, 36, 34, 33, 31, 29, 27, 27, 23, 22, 20, 18, 16, 14, 12, 10,
9, 7, 5, 4, 3, 2, 2, 0, 0, 0, 1, 2, 1, 2, 3, 5, 6, 6, 9, 10, 12, 14, 16, 17, 20,
22, 26, 28, 30, 32, 35, 36, 39, 40, 43, 45, 47, 49, 49, 51, 52, 53, 54, 55, 56,
55, 56, 56, 55, 55, 54, 54, 52, 52, 51, 49, 48, 47, 45, 44, 42, 40, 37, 36, 35,
33, 31, 30, 28, 27, 26, 24, 23, 22, 20, 19, 19, 18, 19, 17, 18, 16, 17, 17, 18,
18, 18, 20, 21, 21, 22, 23, 25, 27, 27, 29, 31, 32, 34, 35, 37, 39, 39, 41, 42,
45, 45, 47, 47, 48, 49, 49, 50, 50, 51, 52, 52, 52, 53, 51, 52, 52, 51, 50, 51,
49, 48, 48, 47, 47, 45, 44, 42, 42, 41, 39, 39, 37, 36, 35, 35, 34, 33, 32, 31,
31, 30, 30, 29, 30, 29, 29, 29, 29, 29, 30, 31, 30, 30, 32, 32, 33, 34, 32, -14,
-38, -1, 0, -12, 1, -1, -14, -20, -31, -43, -52, -58, -62, -66, -68, -71, -75,
-81, -86, -93, -99, -104, -107, -111, -112, -113, -114, -114, -117, -118, -118,
-120, -119, -118, -117, -115, -112, -109, -106, -103, -101, -97, -94, -91, -86,
-81, -77, -73, -69, -63, -60, -55, -51, -47, -43, -38, -35, -31, -27, -24, -22,
-19, -16, -14, -12, -11, -9, -9, -8, -7, -7, -6, -7, -7, -9, -10, -11, -11, -12,
-15, -17, -18, -20, -22, -24, -26, -28, -29, -31, -33, -35, -36, -38, -39, -40,
-41, -42, -43, -43, -44, -45, -43, -43, -43, -42, -41, -40, -39, -37, -35, -34,
-31, -30, -29, -26, -24, -21, -18, -16, -14, -12, -9, -7, -4, -2, -1, };