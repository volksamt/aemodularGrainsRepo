#define DATA_LENGTH 512
#define DATA AKWF_0472

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 2, 3, 4, 4, 6, 6, 7, 8, 9,
9, 10, 11, 11, 12, 12, 14, 14, 15, 15, 16, 16, 17, 18, 18, 19, 20, 20, 21, 21,
22, 23, 24, 24, 26, 26, 27, 28, 28, 30, 30, 31, 31, 33, 34, 34, 35, 35, 36, 37,
39, 39, 40, 40, 42, 42, 43, 44, 45, 45, 46, 47, 48, 49, 50, 50, 52, 52, 52, 54,
55, 55, 56, 57, 58, 59, 60, 61, 62, 63, 63, 65, 66, 65, 67, 68, 69, 69, 71, 72,
72, 73, 74, 75, 75, 77, 77, 78, 79, 80, 81, 82, 83, 83, 84, 86, 85, 87, 88, 89,
90, 91, 92, 93, 93, 94, 95, 96, 97, 97, 98, 99, 100, 102, 102, 103, 104, 105,
107, 107, 108, 109, 109, 110, 111, 112, 112, 113, 112, 108, 87, 44, 5, -9, -5,
2, 3, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1,
1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1,
0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 1,
1, 1, 0, 0, 0, 1, 1, -1, 1, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0,
2, 4, 5, 3, 0, -1, 0, 1, 0, 0, 0, 1, 0, 0, 0, -1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, -1, 0, 0, -1, -1, 0, -1, 0, -1, 0, -1, 0, 0, 0, -1, -1, 0, 0, -1,
-1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0, -1, 0, -1, 0, -1, 0, 0, -1, 0, -1,
-1, 0, -1, -1, -1, 0, 0, -1, 0, 0, -1, 0, -1, -1, -1, 0, -1, -1, -1, -1, -1, 0,
0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, -1, -1, -3, -13, -40,
-80, -109, -120, -117, -112, -110, -109, -110, -109, -108, -108, -107, -105,
-105, -104, -104, -102, -102, -101, -100, -99, -98, -96, -95, -95, -94, -93,
-93, -91, -91, -90, -89, -88, -88, -86, -85, -84, -84, -82, -81, -81, -80, -79,
-78, -77, -77, -75, -75, -74, -73, -73, -71, -70, -70, -68, -67, -66, -65, -65,
-64, -63, -62, -61, -61, -59, -59, -58, -58, -57, -55, -55, -54, -53, -52, -51,
-51, -50, -49, -48, -48, -46, -46, -45, -44, -43, -43, -41, -41, -39, -39, -38,
-38, -37, -35, -35, -35, -34, -32, -32, -32, -30, -29, -29, -28, -27, -26, -25,
-25, -24, -23, -23, -21, -21, -20, -20, -20, -19, -17, -18, -17, -16, -15, -14,
-14, -13, -12, -13, -11, -11, -11, -10, -8, -8, -7, -7, -5, -5, -3, -3, -2, -2,
-2, -1, };