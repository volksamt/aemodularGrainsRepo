#define DATA_LENGTH 512
#define DATA AKWF_0458

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 16, 20, 25, 27, 31, 33, 36, 37, 39,
41, 43, 45, 46, 48, 49, 49, 50, 53, 53, 55, 56, 56, 58, 58, 59, 60, 62, 63, 63,
65, 65, 66, 67, 68, 69, 69, 70, 70, 72, 73, 74, 74, 75, 76, 76, 77, 77, 79, 80,
80, 81, 82, 83, 83, 84, 85, 85, 87, 85, 87, 87, 89, 89, 90, 91, 92, 92, 92, 94,
95, 95, 96, 96, 97, 97, 98, 98, 96, 94, 87, 81, 64, 51, 4, -42, -49, -63, -68,
-75, -80, -83, -85, -85, -85, -84, -84, -83, -83, -83, -83, -83, -83, -84, -85,
-85, -87, -88, -88, -88, -88, -87, -87, -87, -86, -85, -84, -84, -82, -81, -81,
-80, -78, -79, -78, -77, -77, -77, -75, -75, -74, -74, -73, -72, -71, -70, -70,
-69, -68, -67, -66, -66, -64, -64, -63, -62, -62, -60, -60, -59, -57, -56, -55,
-54, -52, -52, -52, -50, -48, -47, -45, -44, -43, -41, -38, -36, -31, -27, -23,
-20, -9, 10, 18, 22, 26, 29, 31, 34, 36, 37, 40, 41, 44, 45, 47, 48, 49, 50, 52,
53, 53, 54, 56, 57, 58, 59, 60, 62, 62, 63, 65, 64, 65, 66, 68, 68, 69, 69, 70,
72, 72, 73, 74, 75, 75, 75, 76, 78, 79, 78, 80, 80, 82, 82, 82, 84, 84, 85, 85,
86, 87, 88, 88, 90, 89, 91, 91, 92, 92, 93, 94, 95, 95, 96, 96, 98, 97, 98, 98,
96, 91, 85, 76, 59, 37, -20, -46, -55, -66, -71, -78, -80, -84, -84, -86, -84,
-85, -84, -84, -83, -84, -83, -83, -84, -85, -85, -86, -87, -88, -88, -88, -88,
-87, -87, -87, -86, -84, -84, -83, -82, -81, -81, -79, -79, -78, -78, -76, -77,
-76, -76, -74, -74, -73, -73, -72, -71, -70, -69, -68, -68, -67, -65, -65, -65,
-64, -63, -61, -61, -60, -59, -57, -56, -56, -55, -54, -52, -51, -51, -48, -47,
-46, -46, -44, -42, -39, -37, -34, -30, -26, -20, -17, -1, 15, 20, 24, 27, 31,
33, 34, 36, 39, 40, 42, 44, 46, 47, 49, 49, 51, 52, 54, 55, 55, 57, 58, 59, 60,
61, 61, 62, 63, 64, 66, 66, 67, 67, 69, 69, 71, 70, 72, 72, 73, 73, 75, 75, 76,
77, 78, 78, 79, 80, 80, 81, 82, 83, 84, 85, 85, 86, 86, 87, 87, 88, 89, 90, 90,
91, 92, 92, 93, 94, 95, 95, 97, 97, 98, 97, 99, 97, 95, 88, 83, 68, 54, 15, -37,
-48, -60, -67, -73, -78, -82, -84, -85, -85, -85, -85, -84, -84, -83, -83, -82,
-84, -84, -86, -86, -87, -87, -89, -88, -88, -88, -87, -87, -85, -85, -84, -83,
-83, -81, -80, -81, -80, -79, -78, -77, -77, -77, -76, -76, -75, -74, -73, -72,
-72, -71, -69, -69, -68, -68, -67, -65, -64, -64, -64, -62, -62, -61, -59, -59,
-58, -56, -56, -54, -53, -52, -51, -51, -49, -48, -46, -45, -42, -41, -38, -36,
-32, -29, -23, -21, -12, };