#define DATA_LENGTH 512
#define DATA AKWF_0430

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 29, 49, 63, 66, 60, 48, 33, 19, 11,
11, 6, 8, 10, 16, 18, 24, 24, 20, 21, 22, 21, 24, 34, 34, 45, 60, 64, 67, 66,
68, 66, 74, 80, 72, 72, 73, 75, 75, 76, 77, 78, 80, 80, 81, 80, 82, 83, 84, 84,
85, 85, 86, 86, 86, 87, 87, 88, 88, 88, 90, 89, 90, 90, 90, 89, 88, 88, 86, 85,
82, 82, 79, 80, 70, 63, 63, 60, 58, 58, 56, 55, 54, 54, 54, 52, 53, 45, 42, 40,
38, 33, 31, 27, 26, 19, 24, 12, 25, -23, -97, -89, -93, -94, -82, -80, -89, -86,
-84, -81, -77, -73, -65, -59, -53, -43, -35, -24, -19, -21, -38, -30, -59, -70,
-85, -97, -69, -80, -72, -75, -71, -71, -69, -68, -68, -67, -67, -66, -67, -65,
-60, -46, -40, -40, -40, -38, -39, -38, -38, -36, -36, -34, -42, -42, -40, -48,
-48, -48, -47, -47, -48, -57, -60, -62, -63, -67, -69, -73, -68, -56, -60, -62,
-64, -67, -70, -72, -74, -76, -77, -79, -81, -82, -82, -84, -84, -85, -84, -85,
-85, -86, -84, -84, -83, -84, -75, -70, -70, -68, -66, -65, -62, -62, -55, -36,
-34, -32, -31, -29, -27, -26, -23, -22, -20, -18, -17, -16, -15, -16, -19, -20,
-21, -21, -24, -10, -1, -4, -1, -2, -1, 1, 2, 5, 6, 10, 10, 14, 14, 22, 27, 25,
24, 22, 21, 16, 15, 10, 8, 0, 3, -11, 10, 4, 10, 0, -34, -12, -2, 24, 38, 51,
49, 43, 28, 13, -4, -11, -13, -20, -17, -17, -13, -10, -4, -8, -12, -12, -10,
-13, -9, -1, -3, 10, 22, 25, 27, 25, 27, 26, 32, 38, 28, 29, 30, 30, 32, 32, 33,
33, 35, 36, 37, 39, 40, 41, 42, 43, 45, 45, 48, 49, 51, 51, 53, 55, 56, 58, 59,
61, 63, 64, 65, 66, 66, 67, 67, 67, 67, 67, 65, 67, 59, 54, 54, 54, 55, 56, 54,
57, 57, 59, 59, 61, 62, 56, 54, 55, 53, 51, 51, 47, 48, 43, 47, 37, 52, -5, -69,
-57, -64, -61, -49, -48, -55, -51, -49, -45, -39, -34, -26, -18, -10, -1, 8, 18,
24, 21, 6, 13, -18, -25, -44, -49, -25, -38, -26, -31, -27, -29, -26, -27, -27,
-28, -29, -28, -30, -28, -24, -11, -6, -8, -9, -9, -11, -10, -11, -11, -12, -12,
-21, -21, -23, -31, -32, -34, -35, -36, -39, -51, -53, -57, -60, -65, -68, -76,
-71, -61, -68, -70, -76, -81, -85, -88, -92, -95, -98, -100, -104, -106, -108,
-110, -112, -113, -115, -116, -117, -118, -118, -118, -118, -119, -111, -107,
-107, -106, -105, -105, -102, -103, -96, -78, -78, -76, -75, -74, -72, -69, -67,
-67, -63, -63, -60, -59, -57, -59, -60, -61, -62, -61, -62, -45, -38, -39, -37,
-35, -32, -30, -27, -24, -21, -17, -14, -10, -9, 2, 6, 6, 7, 7, 5, 3, 2, 0, -1,
-5, -4, -14, 11, 3, 14, -2, -27, -4, };