#define DATA_LENGTH 512
#define DATA AKWF_0482

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 16, 20, 25, 30, 35, 40, 44,
47, 52, 56, 62, 66, 70, 73, 78, 82, 87, 90, 92, 96, 99, 102, 104, 106, 108, 109,
111, 112, 114, 116, 116, 118, 118, 119, 119, 119, 119, 117, 117, 116, 114, 113,
111, 109, 107, 104, 102, 101, 99, 96, 93, 90, 87, 83, 80, 77, 73, 70, 66, 63,
59, 55, 52, 47, 43, 39, 35, 30, 26, 21, 17, 13, 8, 3, -1, -5, -9, -14, -19, -23,
-27, -31, -36, -40, -44, -48, -52, -56, -60, -63, -66, -70, -74, -77, -80, -83,
-85, -88, -91, -93, -95, -97, -99, -101, -102, -103, -104, -106, -106, -108,
-108, -108, -109, -108, -109, -109, -108, -107, -106, -106, -105, -103, -101,
-99, -97, -96, -93, -90, -88, -84, -81, -77, -73, -69, -65, -61, -57, -53, -47,
-43, -38, -33, -28, -24, -18, -13, -9, -3, 1, 6, 11, 15, 21, 25, 30, 34, 38, 42,
46, 51, 54, 58, 62, 64, 68, 72, 74, 77, 79, 81, 83, 85, 87, 89, 90, 91, 91, 92,
93, 93, 93, 94, 94, 92, 93, 92, 90, 88, 87, 86, 84, 82, 79, 78, 76, 73, 70, 67,
64, 61, 59, 56, 51, 49, 45, 41, 38, 34, 30, 26, 23, 18, 14, 10, 7, 4, -1, -4,
-8, -12, -16, -19, -23, -28, -30, -34, -38, -41, -43, -47, -50, -52, -56, -58,
-60, -63, -65, -68, -69, -70, -72, -75, -76, -77, -79, -79, -80, -80, -82, -81,
-81, -83, -81, -82, -81, -80, -81, -79, -79, -78, -77, -74, -73, -72, -70, -68,
-66, -64, -63, -61, -57, -56, -53, -50, -48, -45, -42, -39, -37, -34, -31, -28,
-25, -22, -19, -15, -13, -10, -6, -4, -1, 2, 6, 8, 11, 14, 18, 19, 23, 25, 27,
31, 33, 35, 37, 39, 42, 44, 46, 48, 50, 51, 53, 55, 56, 57, 57, 59, 60, 61, 61,
62, 63, 63, 63, 63, 64, 63, 63, 63, 62, 62, 62, 61, 60, 59, 58, 57, 56, 55, 53,
52, 51, 49, 47, 45, 43, 41, 40, 39, 36, 33, 31, 29, 28, 25, 23, 20, 18, 17, 14,
11, 9, 7, 5, 3, -1, -3, -5, -6, -9, -11, -12, -15, -18, -19, -21, -23, -24, -26,
-28, -30, -31, -33, -34, -35, -37, -39, -39, -41, -41, -42, -43, -43, -44, -45,
-45, -46, -46, -46, -47, -46, -47, -46, -46, -46, -46, -45, -44, -44, -43, -43,
-42, -41, -41, -40, -39, -37, -36, -35, -34, -33, -31, -29, -28, -27, -25, -24,
-22, -20, -19, -18, -15, -14, -13, -10, -9, -7, -6, -3, -2, -1, 1, 2, 5, 6, 8,
8, 9, 10, 9, 8, 8, 6, 5, 3, 1, -1, -3, -6, -8, -9, -12, -14, -16, -18, -21, -22,
-26, -27, -30, -33, -34, -37, -38, -40, -43, -44, -45, -46, -48, -48, -49, -51,
-51, -52, -52, -53, -54, -53, -52, -51, -49, -48, -46, -44, -41, -38, -36, -32,
-30, -27, -24, -19, -17, -13, -9, -6, -2, };