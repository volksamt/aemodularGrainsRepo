#define DATA_LENGTH 512
#define DATA AKWF_0438

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 6, 4, 2, 3, 3, 4, 1, 1, 1, 1, 2, 2,
1, 1, 1, 0, 0, 1, 1, 1, 2, 7, 13, 16, 12, 6, 3, 3, 8, 10, 11, 13, 16, 17, 19,
21, 23, 25, 26, 29, 30, 33, 34, 36, 38, 40, 42, 44, 45, 48, 49, 50, 53, 53, 56,
56, 59, 61, 62, 64, 65, 66, 68, 70, 70, 73, 74, 76, 77, 78, 80, 81, 82, 83, 84,
86, 88, 89, 89, 91, 92, 93, 93, 96, 96, 97, 99, 100, 100, 102, 102, 102, 104,
105, 105, 107, 107, 109, 108, 110, 110, 112, 111, 112, 112, 112, 114, 114, 114,
115, 115, 117, 117, 117, 117, 118, 118, 118, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 118, 119, 118, 117, 118, 118, 117, 117, 116,
117, 115, 115, 115, 115, 115, 113, 113, 112, 112, 111, 109, 109, 109, 109, 107,
106, 106, 105, 103, 103, 102, 102, 100, 98, 99, 98, 97, 95, 94, 93, 92, 90, 90,
89, 87, 86, 85, 84, 82, 80, 79, 78, 76, 75, 73, 73, 71, 69, 68, 66, 65, 63, 62,
60, 58, 57, 55, 53, 52, 50, 48, 46, 44, 43, 42, 40, 38, 37, 34, 33, 30, 29, 28,
25, 23, 21, 19, 17, 15, 14, 11, 9, 7, 5, 3, 5, 9, 15, 15, 9, 2, -1, 0, 0, 0, 1,
1, 1, 1, 1, 2, 1, 0, 1, 0, 2, 3, 3, 3, 1, 3, 6, 2, -4, -6, -4, -2, -3, -4, -3,
-2, -1, -1, -1, -1, -2, 0, -1, -1, -1, -1, 0, 0, -1, -3, -8, -14, -16, -12, -6,
-2, -4, -7, -11, -12, -14, -15, -18, -20, -21, -23, -26, -28, -29, -31, -32,
-35, -36, -38, -39, -42, -44, -46, -46, -49, -50, -52, -55, -56, -57, -58, -60,
-62, -63, -65, -67, -68, -70, -71, -73, -74, -76, -77, -79, -79, -81, -82, -83,
-85, -86, -87, -89, -90, -90, -93, -93, -94, -95, -97, -98, -99, -99, -101,
-101, -103, -103, -104, -105, -106, -106, -107, -108, -109, -109, -110, -111,
-111, -112, -113, -114, -114, -114, -115, -116, -115, -117, -117, -117, -117,
-118, -117, -119, -117, -119, -119, -119, -119, -119, -119, -118, -119, -118,
-119, -119, -118, -118, -118, -119, -118, -117, -118, -118, -117, -116, -116,
-116, -116, -115, -114, -114, -113, -113, -113, -113, -111, -110, -110, -110,
-108, -108, -107, -106, -106, -105, -104, -103, -102, -101, -100, -99, -98, -98,
-97, -95, -94, -93, -91, -91, -90, -88, -87, -86, -85, -83, -82, -81, -79, -77,
-76, -76, -74, -73, -70, -70, -68, -67, -65, -63, -62, -61, -59, -56, -55, -53,
-51, -51, -48, -47, -45, -44, -41, -39, -37, -36, -34, -32, -30, -29, -26, -25,
-23, -21, -19, -18, -15, -13, -10, -9, -6, -5, -3, -5, -10, -15, -14, -8, -1, 1,
1, 0, -1, 0, 0, -1, -1, -1, -2, -1, -1, 0, -1, -2, -3, -3, -2, -2, -3, -5, -1,
};