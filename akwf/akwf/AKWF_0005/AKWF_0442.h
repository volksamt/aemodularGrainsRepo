#define DATA_LENGTH 512
#define DATA AKWF_0442

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 15, 19, 22, 25, 28, 31, 33,
35, 37, 39, 41, 43, 45, 47, 44, 37, 34, 35, 36, 38, 34, 28, 30, 34, 33, 33, 31,
31, 32, 33, 33, 33, 34, 34, 34, 35, 35, 35, 34, 34, 33, 32, 32, 30, 29, 27, 26,
24, 22, 21, 18, 17, 14, 10, 8, 5, 1, -11, -22, -27, -30, -32, -35, -38, -39,
-41, -42, -44, -45, -46, -48, -49, -51, -50, -51, -52, -52, -52, -51, -52, -51,
-50, -51, -52, -54, -57, -58, -58, -59, -61, -62, -62, -63, -64, -64, -64, -64,
-64, -64, -68, -78, -85, -89, -90, -90, -92, -93, -94, -95, -96, -98, -98, -99,
-101, -102, -102, -104, -105, -104, -105, -105, -104, -103, -102, -103, -103,
-102, -103, -102, -103, -103, -102, -102, -102, -102, -102, -103, -103, -103,
-101, -102, -101, -105, -114, -118, -119, -119, -117, -118, -117, -117, -117,
-111, -94, -79, -69, -60, -55, -51, -50, -46, -45, -44, -44, -43, -42, -42, -41,
-42, -42, -42, -43, -45, -45, -46, -48, -48, -49, -51, -53, -55, -57, -59, -60,
-63, -74, -84, -89, -91, -91, -92, -93, -94, -92, -92, -91, -91, -88, -85, -86,
-86, -84, -82, -79, -77, -73, -70, -65, -61, -57, -54, -52, -50, -48, -45, -43,
-39, -35, -30, -27, -22, -19, -13, -8, -2, 3, 8, 10, 7, 6, 9, 14, 22, 32, 40,
47, 56, 60, 37, 26, 33, 28, 24, 20, 18, 17, 13, 10, 7, 3, -1, -4, -8, -9, -12,
-14, -14, -14, -13, -12, -12, -9, -8, -5, -4, 1, 2, 9, -19, -90, -49, 12, 5, 9,
32, 56, 63, 59, 49, 39, 32, 31, 34, 39, 46, 52, 61, 74, 78, 78, 78, 80, 84, 84,
84, 85, 86, 86, 87, 87, 88, 88, 88, 88, 89, 88, 88, 87, 87, 86, 84, 83, 81, 73,
64, 60, 59, 60, 59, 59, 60, 61, 61, 62, 62, 64, 65, 65, 66, 68, 70, 70, 73, 75,
76, 78, 81, 83, 84, 85, 83, 84, 83, 84, 84, 84, 84, 85, 85, 85, 86, 86, 88, 88,
90, 86, 76, 70, 68, 68, 68, 67, 67, 67, 66, 66, 65, 64, 63, 64, 64, 62, 63, 63,
63, 63, 64, 66, 68, 68, 70, 70, 71, 73, 73, 74, 76, 76, 76, 78, 79, 80, 80, 82,
83, 83, 85, 86, 80, 72, 69, 70, 71, 70, 71, 70, 71, 72, 72, 73, 72, 71, 72, 72,
72, 71, 70, 71, 70, 70, 69, 69, 69, 67, 66, 64, 63, 61, 59, 56, 54, 53, 50, 48,
45, 43, 39, 36, 33, 29, 24, 11, 2, -4, -8, -10, -12, -15, -17, -18, -20, -22,
-24, -24, -29, -30, -28, -29, -29, -29, -29, -29, -28, -27, -27, -26, -26, -27,
-29, -30, -31, -31, -31, -31, -32, -31, -32, -31, -30, -30, -28, -29, -29, -32,
-42, -47, -48, -48, -50, -55, -57, -57, -59, -60, -60, -62, -61, -60, -57, -54,
-49, -43, -38, -33, -25, -19, -13, -7, -2, };