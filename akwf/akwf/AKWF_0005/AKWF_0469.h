#define DATA_LENGTH 512
#define DATA AKWF_0469

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 17, 20, 24, 27, 30, 34,
37, 41, 44, 47, 51, 54, 58, 62, 65, 69, 73, 77, 81, 85, 89, 92, 97, 99, 102,
105, 109, 112, 113, 115, 116, 117, 118, 119, 119, 119, 118, 117, 116, 115, 113,
111, 110, 107, 104, 102, 98, 95, 92, 90, 87, 84, 80, 76, 74, 70, 68, 66, 62, 60,
57, 54, 51, 50, 47, 47, 45, 43, 42, 40, 40, 38, 38, 37, 37, 36, 36, 36, 36, 36,
36, 36, 36, 37, 37, 37, 38, 37, 38, 38, 39, 39, 40, 39, 40, 40, 40, 40, 41, 41,
41, 41, 42, 41, 41, 41, 41, 41, 41, 40, 40, 39, 39, 40, 39, 39, 39, 38, 38, 39,
38, 37, 37, 37, 36, 36, 36, 37, 36, 35, 35, 36, 36, 35, 35, 35, 35, 34, 35, 35,
34, 34, 34, 34, 34, 35, 34, 34, 35, 34, 34, 35, 34, 34, 34, 34, 34, 35, 34, 34,
35, 35, 35, 35, 35, 34, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35,
35, 35, 35, 36, 35, 35, 36, 35, 35, 36, 36, 35, 36, 35, 36, 36, 35, 35, 37, 37,
37, 37, 35, 36, 36, 36, 35, 37, 36, 36, 37, 36, 37, 37, 36, 37, 37, 36, 37, 37,
37, 38, 38, 37, 38, 37, 38, 38, 38, 38, 38, 38, 39, 39, 39, 38, 38, 39, 39, 38,
39, 40, 40, 39, 38, 37, 34, 31, 26, 23, 21, 20, 17, 16, 15, 14, 14, 11, 8, 6, 4,
2, 1, -1, -2, -4, -5, -6, -7, -7, -9, -10, -10, -11, -12, -13, -15, -15, -17,
-19, -20, -22, -23, -25, -26, -28, -29, -30, -32, -33, -35, -36, -37, -39, -40,
-40, -42, -42, -43, -44, -44, -44, -44, -44, -44, -45, -45, -45, -45, -43, -44,
-44, -42, -42, -42, -41, -41, -40, -39, -39, -38, -38, -37, -36, -36, -36, -34,
-35, -34, -34, -34, -33, -34, -32, -32, -33, -33, -32, -32, -32, -33, -32, -32,
-32, -33, -32, -33, -32, -33, -33, -34, -33, -33, -34, -34, -34, -34, -34, -34,
-35, -35, -35, -36, -36, -35, -36, -36, -36, -35, -37, -36, -36, -36, -36, -37,
-36, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -38, -37, -37,
-38, -38, -38, -37, -38, -38, -38, -38, -39, -38, -39, -39, -39, -39, -39, -39,
-40, -39, -40, -41, -41, -42, -41, -42, -42, -42, -43, -43, -44, -43, -45, -45,
-45, -46, -46, -46, -46, -47, -48, -49, -49, -49, -49, -50, -51, -51, -53, -53,
-54, -54, -55, -56, -57, -57, -57, -59, -60, -60, -61, -63, -64, -65, -66, -67,
-68, -69, -71, -72, -73, -75, -77, -78, -80, -82, -83, -85, -86, -88, -89, -92,
-94, -96, -98, -100, -101, -104, -105, -107, -108, -109, -109, -109, -109, -109,
-107, -106, -104, -101, -98, -94, -90, -86, -81, -76, -69, -64, -58, -52, -45,
-40, -35, -29, -23, -17, -13, -8, -3, };