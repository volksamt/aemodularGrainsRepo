#define DATA_LENGTH 512
#define DATA AKWF_0460

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 11, 11, 11, 10, 11, 11, 10, 14, 24,
21, 22, 21, 26, 34, 32, 33, 32, 33, 32, 33, 31, 33, 31, 35, 44, 43, 43, 43, 43,
43, 43, 44, 43, 44, 53, 54, 53, 54, 54, 54, 53, 55, 54, 54, 55, 54, 54, 53, 59,
66, 64, 66, 65, 65, 65, 66, 65, 66, 65, 65, 65, 66, 64, 66, 76, 75, 76, 76, 75,
75, 75, 75, 76, 76, 75, 75, 76, 75, 76, 76, 76, 76, 76, 75, 76, 76, 75, 77, 75,
81, 88, 87, 86, 86, 87, 87, 87, 86, 86, 86, 87, 86, 86, 87, 86, 87, 87, 87, 87,
86, 86, 87, 86, 87, 87, 86, 86, 87, 87, 86, 87, 86, 87, 85, 92, 99, 96, 98, 97,
98, 98, 98, 97, 98, 98, 97, 98, 97, 97, 97, 97, 97, 98, 97, 98, 97, 97, 97, 97,
97, 97, 98, 97, 97, 97, 98, 98, 97, 98, 97, 98, 97, 97, 97, 97, 97, 97, 97, 98,
98, 97, 97, 98, 97, 97, 97, 97, 98, 97, 97, 97, 102, 109, 107, 109, 108, 108,
109, 109, 108, 108, 108, 107, 108, 108, 108, 109, 108, 108, 108, 108, 108, 107,
108, 108, 109, 108, 108, 109, 108, 108, 108, 108, 108, 108, 108, 109, 107, 109,
107, 108, 109, 108, 108, 107, 109, 107, 108, 107, 109, 107, 109, 107, 110, 106,
109, 106, 110, 106, 111, 105, 111, 105, 114, 94, 47, 62, 0, -31, -59, -68, -66,
-79, -80, -91, -94, -100, -94, -107, -108, -109, -108, -108, -113, -120, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -120, -118, -119, -118, -120,
-118, -108, -108, -109, -109, -109, -107, -108, -108, -108, -108, -108, -108,
-108, -107, -108, -107, -108, -109, -108, -108, -108, -109, -108, -109, -107,
-108, -108, -108, -108, -108, -108, -108, -108, -109, -108, -109, -109, -108,
-108, -108, -108, -108, -108, -108, -108, -108, -108, -108, -108, -108, -108,
-107, -108, -109, -107, -109, -107, -109, -105, -96, -98, -97, -97, -97, -97,
-97, -97, -98, -97, -97, -98, -97, -98, -97, -97, -97, -98, -98, -98, -98, -98,
-98, -98, -97, -98, -97, -98, -97, -98, -97, -97, -96, -99, -95, -86, -87, -87,
-87, -87, -87, -87, -87, -87, -86, -86, -86, -87, -87, -87, -87, -87, -87, -87,
-86, -86, -85, -76, -75, -76, -76, -76, -76, -75, -76, -76, -76, -75, -76, -76,
-76, -76, -77, -76, -77, -72, -63, -66, -65, -65, -66, -64, -65, -65, -66, -64,
-67, -61, -53, -55, -53, -54, -54, -55, -54, -54, -54, -55, -52, -41, -44, -42,
-44, -43, -44, -43, -43, -43, -34, -32, -33, -32, -33, -33, -32, -33, -29, -20,
-21, -22, -21, -23, -18, -9, -11, -11, -10, -12, -6, 2, -1, 1, -1, };