#define DATA_LENGTH 512
#define DATA AKWF_0414

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 6, 8, 9, 11, 13, 14, 14, 14,
15, 16, 16, 16, 16, 17, 16, 15, 15, 14, 14, 13, 13, 12, 11, 10, 10, 10, 9, 9, 9,
8, 9, 9, 8, 8, 8, 8, 8, 8, 7, 8, 8, 8, 9, 9, 8, 8, 8, 10, 10, 9, 10, 11, 10, 11,
11, 12, 12, 13, 13, 13, 15, 14, 16, 17, 17, 17, 18, 19, 19, 20, 21, 22, 22, 23,
24, 25, 27, 28, 28, 29, 31, 32, 33, 34, 36, 37, 39, 39, 41, 43, 44, 45, 46, 48,
49, 50, 51, 53, 53, 55, 56, 57, 58, 60, 60, 62, 63, 64, 64, 66, 67, 68, 69, 71,
72, 72, 75, 74, 76, 76, 78, 79, 81, 75, 38, -31, -33, -4, -19, -9, -12, -10,
-10, -9, -9, -9, -8, -9, -8, -9, -8, -8, -7, -8, -8, -8, -7, -8, -8, -8, -8, -9,
-8, -9, -9, -10, -10, -10, -11, -11, -12, -12, -13, -13, -14, -14, -15, -15,
-15, -16, -16, -16, -16, -15, -16, -14, -14, -13, -12, -11, -9, -8, -6, -4, -2,
-1, 2, 4, 6, 7, 8, 10, 12, 13, 14, 15, 15, 16, 15, 16, 16, 16, 15, 15, 15, 14,
14, 13, 13, 12, 12, 11, 11, 10, 10, 10, 9, 9, 8, 9, 8, 8, 8, 8, 7, 8, 7, 8, 7,
7, 8, 9, 8, 9, 8, 10, 9, 9, 10, 10, 10, 11, 11, 12, 12, 11, 14, 12, 15, 13, 16,
10, 3, -37, -25, -8, -23, -8, -17, -11, -14, -11, -12, -11, -10, -10, -10, -11,
-9, -10, -7, -9, -7, -9, -8, -8, -7, -8, -7, -8, -8, -8, -8, -9, -8, -8, -8, -8,
-10, -10, -10, -9, -11, -11, -11, -12, -12, -13, -15, -14, -15, -14, -15, -16,
-16, -17, -16, -16, -16, -15, -14, -13, -11, -12, -10, -8, -7, -5, -3, -1, 1, 3,
6, 7, 8, 9, 11, 12, 13, 14, 15, 16, 16, 15, 16, 16, 15, 16, 16, 14, 15, 14, 13,
12, 12, 11, 11, 12, 10, 11, 10, 9, 9, 9, 7, 8, 7, 8, 8, 9, 8, 9, 8, 8, 8, 8, 9,
8, 9, 8, 10, 8, 11, 8, 12, 8, 15, 8, 16, 6, -1, -87, -102, -56, -93, -68, -82,
-72, -75, -73, -71, -72, -69, -70, -66, -68, -64, -67, -62, -64, -59, -61, -57,
-58, -56, -56, -54, -54, -51, -51, -49, -48, -47, -46, -45, -43, -41, -40, -40,
-38, -37, -35, -34, -32, -31, -29, -30, -28, -28, -26, -25, -24, -23, -22, -21,
-20, -19, -19, -18, -18, -17, -16, -15, -15, -14, -14, -14, -13, -13, -11, -11,
-11, -10, -10, -10, -10, -9, -9, -9, -8, -9, -8, -8, -8, -7, -9, -8, -8, -8, -8,
-7, -8, -8, -9, -8, -8, -8, -9, -10, -10, -10, -10, -10, -11, -13, -13, -13,
-14, -14, -14, -15, -16, -15, -16, -16, -16, -15, -15, -15, -14, -14, -12, -10,
-9, -7, -6, -4, -3, 0, };