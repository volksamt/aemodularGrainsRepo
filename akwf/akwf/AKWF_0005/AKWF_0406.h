#define DATA_LENGTH 512
#define DATA AKWF_0406

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 31, 40, 55, 69, 83, 93, 98, 100,
97, 89, 79, 62, 44, 25, 7, -10, -24, -35, -42, -46, -48, -47, -45, -40, -36,
-30, -24, -19, -14, -10, -5, -1, 0, 2, 3, 3, 4, 3, 3, 2, 1, 1, -1, -2, -1, -2,
-3, -3, -2, -2, -3, -2, -2, -1, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 1, 0, 1, 0, -1, 1, 0, 0, 0, 0, 1, 0, 0, 0,
0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, -1,
0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 1, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, -1, -1, 0, 0, -1, 0, -1, 1, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0,
0, 0, 0, -1, 0, -1, 0, 1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, -1, 0, -1, 1, -1, 1, 0, 1, -1, 1, 0, 1, 0, 0, -1, 1, 0, 1,
-1, -1, 1, -1, 1, -85, -120, -111, -96, -53, -28, 6, 34, 67, 86, 102, 105, 104,
96, 86, 71, 56, 38, 21, 4, -10, -22, -32, -38, -42, -43, -43, -39, -36, -30,
-25, -19, -15, -10, -5, -2, 1, 3, 4, 5, 5, 6, 5, 4, 3, 2, 1, 0, 0, 0, -1, -1,
-2, -2, -2, -2, -2, -1, -1, 0, -1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 1, -1, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 1, 0,
-1, 1, 0, 0, 0, 1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0, -1, -1, 0, 0, 1, 0, 0, 0, 0,
0, 0, 1, 1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, 1, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0,
0, 1, -1, -1, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1,
0, 0, 0, 1, 0, -1, 0, 0, 1, 0, 0, -1, 1, -2, 1, -1, 1, -1, 1, -1, 2, -9, -74,
-105, -67, -50, -30, -9, -63, -58, -34, -11, };