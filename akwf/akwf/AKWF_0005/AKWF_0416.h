#define DATA_LENGTH 512
#define DATA AKWF_0416

const PROGMEM int8_t DATA[DATA_LENGTH] = {70, 52, 63, 60, 30, 29, 2, 4, -14, -8,
-18, -12, -17, -11, -13, -8, -7, -5, -4, -2, -1, -1, 1, 0, 1, 1, 3, 0, 2, 1, 2,
2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 2, 1, 2, 2, 2, 1, 2, 1, 1, 0, 0, -1, -1, -2,
-1, -1, -1, -2, -2, -3, -4, -3, -3, -3, -2, -3, -1, -2, -1, 0, 0, 0, 1, 1, 1, 1,
3, 2, 2, 2, 2, 2, 2, 2, 1, 1, 1, 1, 0, 1, -1, 0, -2, 0, -1, 0, -2, 0, -1, 0, -1,
0, -1, 0, 0, 0, 0, -1, 0, -1, 1, -2, 2, -3, 3, -3, 4, -4, 4, -5, 5, -8, -16,
-85, -53, 76, 21, 58, 31, 24, 16, 1, 1, -11, -5, -15, -6, -13, -5, -10, -4, -7,
-1, -4, 0, -1, 1, 0, 1, 1, 1, 1, 1, 2, 0, 2, 0, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 1,
0, 0, 0, 1, 0, 1, 1, 1, 1, 2, 2, 1, 2, 0, 1, 1, 1, 0, 0, -1, 0, 0, -1, 0, -2,
-2, -4, -4, -4, -3, -4, -3, -2, -2, -1, -1, 0, 0, 0, 0, 2, 1, 1, 2, 2, 2, 3, 2,
2, 1, 2, 1, 1, 0, 0, -1, 0, 0, -1, 0, -1, 1, -1, 0, -2, 1, -2, 1, -2, 2, -3, 2,
-3, 3, -3, 2, -2, 1, -1, 1, 1, -4, -14, -67, -12, -37, 26, 40, 32, 46, 19, 29,
3, 11, -6, 0, -12, -5, -13, -7, -9, -7, -7, -5, -4, -4, -1, -2, 1, 0, 2, -1, 2,
1, 2, 0, 2, 1, 2, 1, 1, 0, 1, 0, 1, 0, 1, 0, -1, 0, -1, 0, -1, -1, -1, -1, -2,
-1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0,
1, 1, 1, 1, 1, 2, 0, 0, 2, 2, 2, 2, 2, 2, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, -1, -2,
-3, -4, -4, -3, -3, -3, -3, -2, -2, -1, 0, 0, 0, 1, 0, 1, 1, 2, 2, 2, 3, 3, 2,
2, 2, 2, 1, 1, 1, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, -1, -1, -1, -1, 0, 0, -1, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 1, 0, 1,
0, 0, 0, 1, 0, 0, 0, 0, 0, -1, -1, -1, -1, -1, -2, 0, -1, -1, 0, 0, 0, 1, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, -1, 0, -1,
1, 1, -9, -114, -93, };