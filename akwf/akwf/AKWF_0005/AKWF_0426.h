#define DATA_LENGTH 512
#define DATA AKWF_0426

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 10, 13, 16, 20, 22, 26, 28,
32, 36, 38, 41, 44, 47, 49, 52, 55, 58, 60, 62, 64, 67, 70, 72, 74, 76, 78, 81,
82, 84, 86, 88, 90, 91, 93, 95, 97, 98, 100, 101, 102, 103, 105, 107, 107, 107,
108, 110, 111, 112, 113, 113, 114, 114, 116, 116, 117, 117, 118, 118, 118, 119,
118, 119, 120, 119, 119, 118, 120, 119, 119, 119, 119, 118, 117, 117, 117, 117,
116, 115, 114, 114, 113, 112, 112, 111, 110, 109, 107, 108, 106, 104, 103, 103,
100, 100, 98, 97, 95, 94, 92, 90, 89, 87, 85, 83, 81, 80, 77, 75, 73, 72, 69,
67, 65, 62, 61, 58, 56, 53, 51, 49, 47, 44, 41, 38, 36, 33, 30, 27, 24, 23, 19,
17, 13, 11, 8, 5, 2, 0, -3, -6, -8, -11, -14, -17, -19, -22, -24, -27, -29, -31,
-33, -37, -38, -41, -43, -45, -46, -49, -50, -52, -54, -55, -57, -60, -60, -61,
-63, -64, -67, -67, -69, -70, -70, -73, -73, -75, -75, -76, -76, -77, -78, -78,
-79, -80, -80, -82, -80, -82, -81, -82, -82, -82, -82, -82, -83, -83, -83, -81,
-81, -81, -81, -80, -80, -79, -79, -78, -77, -77, -75, -76, -75, -74, -72, -71,
-70, -69, -69, -68, -65, -65, -63, -62, -61, -59, -58, -55, -55, -53, -51, -50,
-47, -46, -45, -42, -40, -38, -36, -33, -31, -30, -27, -25, -23, -22, -19, -16,
-14, -12, -9, -7, -5, -2, 0, 3, 5, 7, 10, 13, 15, 16, 19, 21, 25, 26, 28, 29,
32, 34, 36, 39, 41, 43, 45, 46, 49, 49, 52, 54, 55, 56, 58, 59, 61, 62, 64, 64,
67, 68, 69, 70, 71, 71, 73, 75, 74, 75, 77, 77, 77, 78, 79, 79, 81, 81, 81, 81,
82, 81, 81, 82, 82, 82, 82, 82, 82, 81, 81, 81, 81, 81, 80, 79, 79, 78, 78, 77,
76, 76, 75, 73, 73, 72, 70, 70, 68, 68, 66, 64, 63, 61, 61, 58, 56, 55, 54, 52,
50, 48, 46, 44, 42, 39, 38, 36, 33, 31, 29, 26, 23, 21, 19, 16, 14, 11, 9, 6, 2,
0, -2, -6, -9, -11, -14, -18, -20, -23, -25, -29, -31, -34, -36, -39, -41, -44,
-47, -49, -51, -54, -56, -58, -61, -63, -65, -68, -69, -72, -74, -76, -78, -81,
-83, -84, -86, -87, -89, -91, -92, -93, -96, -98, -98, -100, -101, -102, -104,
-105, -106, -107, -108, -109, -110, -111, -113, -112, -114, -114, -115, -115,
-116, -117, -116, -118, -118, -118, -118, -119, -118, -119, -119, -119, -120,
-118, -119, -118, -118, -118, -118, -117, -117, -116, -117, -117, -115, -115,
-114, -113, -112, -111, -110, -110, -109, -108, -107, -105, -105, -103, -102,
-101, -99, -98, -96, -95, -94, -91, -89, -88, -86, -84, -82, -80, -78, -75, -73,
-71, -69, -66, -64, -61, -59, -56, -53, -51, -49, -45, -43, -39, -37, -35, -31,
-29, -25, -22, -19, -16, -13, -9, -5, -3, };