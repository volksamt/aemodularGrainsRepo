#define DATA_LENGTH 512
#define DATA AKWF_0466

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 13, 17, 20, 22, 25, 27, 30,
31, 34, 35, 36, 38, 39, 41, 41, 42, 43, 45, 46, 47, 48, 49, 50, 51, 52, 52, 53,
53, 54, 55, 55, 54, 54, 53, 53, 53, 52, 50, 48, 47, 46, 44, 42, 39, 37, 34, 33,
30, 27, 25, 22, 20, 16, 14, 11, 10, 7, 5, 2, 1, -1, -5, -6, -7, -9, -10, -12,
-14, -15, -15, -16, -17, -18, -18, -20, -21, -20, -21, -20, -22, -21, -22, -22,
-21, -22, -22, -21, -21, -21, -20, -21, -20, -20, -19, -20, -20, -19, -18, -18,
-17, -18, -17, -16, -16, -15, -15, -14, -14, -13, -13, -14, -13, -12, -11, -11,
-11, -11, -10, -10, -10, -9, -9, -9, -8, -8, -8, -8, -7, -7, -7, -7, -7, -7, -7,
-7, -6, -7, -7, -6, -6, -6, -6, -5, -5, -6, -5, -5, -5, -5, -4, -5, -5, -4, -3,
-3, -4, -3, -2, -1, -2, -1, -1, 0, -1, 0, 0, 1, 2, 3, 3, 3, 3, 4, 5, 5, 5, 7, 7,
7, 8, 8, 8, 9, 10, 11, 10, 11, 11, 12, 11, 13, 13, 13, 14, 14, 16, 19, 24, 31,
41, 49, 58, 65, 71, 75, 77, 78, 78, 75, 71, 66, 60, 53, 45, 36, 26, 16, 6, -5,
-17, -27, -36, -47, -54, -62, -68, -74, -78, -81, -84, -86, -87, -88, -87, -87,
-85, -82, -79, -75, -72, -67, -63, -59, -54, -50, -45, -39, -35, -31, -27, -22,
-19, -14, -11, -7, -5, -2, 0, 4, 7, 8, 10, 12, 14, 15, 17, 18, 20, 22, 23, 24,
25, 27, 28, 29, 30, 32, 33, 33, 35, 36, 36, 37, 38, 39, 39, 39, 39, 39, 39, 39,
39, 38, 38, 37, 36, 35, 34, 32, 31, 29, 28, 26, 25, 23, 21, 20, 17, 15, 15, 11,
9, 9, 7, 5, 2, 1, -1, -1, -2, -4, -5, -7, -9, -9, -9, -10, -12, -12, -13, -14,
-15, -16, -16, -17, -17, -17, -17, -18, -19, -18, -19, -19, -19, -19, -19, -20,
-20, -19, -19, -18, -19, -19, -19, -19, -19, -18, -19, -18, -18, -17, -17, -17,
-17, -16, -17, -17, -16, -15, -15, -15, -15, -15, -15, -15, -14, -13, -14, -13,
-13, -14, -13, -13, -12, -12, -12, -12, -12, -11, -12, -12, -11, -11, -10, -11,
-11, -9, -10, -10, -10, -9, -9, -8, -7, -8, -8, -8, -7, -7, -6, -6, -5, -5, -5,
-5, -4, -4, -2, -2, -2, -2, 0, 0, 1, 1, 2, 3, 3, 4, 4, 5, 6, 5, 7, 8, 8, 8, 9,
10, 11, 11, 11, 13, 14, 14, 14, 15, 15, 15, 17, 17, 20, 26, 34, 45, 59, 72, 86,
98, 108, 115, 119, 119, 117, 113, 107, 98, 89, 80, 67, 54, 40, 24, 10, -7, -23,
-38, -53, -66, -76, -86, -95, -102, -108, -111, -115, -118, -117, -117, -115,
-114, -109, -105, -99, -94, -86, -80, -73, -66, -59, -53, -46, -39, -32, -26,
-19, -14, -8, -3, };