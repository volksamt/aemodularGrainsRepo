#define DATA_LENGTH 512
#define DATA AKWF_0456

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 8, 8, 8, 10, 11, 12, 12, 9,
7, 8, 13, 18, 23, 26, 31, 34, 37, 40, 43, 47, 48, 52, 55, 57, 60, 63, 65, 68,
70, 72, 74, 76, 78, 80, 81, 83, 85, 86, 88, 88, 90, 91, 92, 93, 94, 96, 96, 97,
99, 99, 99, 100, 101, 102, 103, 103, 104, 105, 105, 106, 106, 107, 108, 107,
109, 110, 110, 110, 110, 110, 110, 111, 112, 112, 112, 113, 113, 113, 113, 114,
114, 115, 114, 115, 114, 116, 115, 116, 116, 115, 116, 116, 116, 116, 117, 117,
117, 117, 116, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 119, 118,
118, 118, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119,
119, 120, 119, 118, 119, 119, 119, 119, 118, 119, 118, 119, 118, 118, 118, 119,
118, 119, 118, 118, 118, 118, 117, 117, 118, 117, 118, 117, 118, 117, 117, 116,
117, 117, 117, 117, 115, 116, 116, 115, 115, 115, 115, 114, 115, 114, 114, 113,
113, 113, 112, 112, 113, 112, 111, 110, 111, 111, 109, 109, 109, 108, 108, 107,
107, 106, 106, 105, 105, 104, 104, 103, 102, 102, 100, 100, 99, 99, 97, 96, 96,
95, 94, 93, 91, 90, 90, 88, 87, 85, 84, 81, 80, 79, 77, 74, 72, 70, 69, 66, 62,
60, 57, 54, 51, 47, 42, 38, 31, 27, 27, 28, 29, 30, 27, 25, 24, 24, 22, 20, 18,
14, 10, 6, 3, -2, -5, -6, -8, -7, -7, -9, -11, -12, -11, -9, -7, -9, -12, -18,
-23, -27, -31, -34, -37, -41, -44, -47, -50, -52, -54, -58, -59, -63, -65, -68,
-70, -72, -74, -76, -78, -79, -81, -82, -84, -86, -87, -89, -90, -92, -92, -93,
-95, -95, -96, -97, -98, -100, -100, -101, -101, -103, -103, -103, -104, -104,
-105, -106, -107, -107, -107, -108, -108, -109, -109, -109, -111, -110, -111,
-112, -111, -113, -113, -113, -113, -113, -113, -114, -114, -115, -115, -115,
-115, -115, -115, -115, -115, -116, -117, -116, -116, -117, -117, -117, -117,
-118, -118, -117, -118, -118, -117, -119, -118, -118, -118, -118, -119, -119,
-119, -118, -118, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119,
-119, -120, -119, -119, -119, -118, -119, -119, -119, -119, -118, -120, -119,
-119, -118, -119, -119, -119, -119, -118, -118, -119, -119, -118, -118, -118,
-118, -118, -117, -117, -118, -117, -117, -117, -117, -117, -117, -117, -116,
-116, -116, -116, -116, -116, -115, -115, -114, -115, -114, -114, -114, -114,
-113, -113, -114, -112, -112, -111, -112, -111, -111, -111, -109, -110, -109,
-109, -108, -108, -108, -107, -107, -106, -106, -104, -104, -103, -103, -103,
-101, -101, -100, -100, -98, -98, -96, -96, -94, -93, -92, -92, -90, -90, -87,
-86, -85, -83, -82, -80, -78, -76, -74, -72, -70, -69, -65, -62, -60, -56, -53,
-50, -45, -42, -37, -31, -28, -26, -27, -29, -29, -28, -24, -24, -22, -22, -20,
-18, -14, -11, -6, -1, };