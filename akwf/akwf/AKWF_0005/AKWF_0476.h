#define DATA_LENGTH 512
#define DATA AKWF_0476

const PROGMEM int8_t DATA[DATA_LENGTH] = {25, 40, 44, 51, 52, 54, 54, 53, 50,
49, 45, 44, 40, 37, 33, 31, 28, 26, 24, 21, 20, 18, 16, 14, 14, 13, 13, 12, 12,
12, 13, 10, 4, 6, 6, 6, 7, 8, 8, 8, 8, 10, 10, 11, 11, 13, 13, 13, 13, 15, 14,
16, 15, 16, 17, 17, 17, 16, 18, 17, 17, 18, 17, 22, 27, 26, 26, 26, 26, 26, 27,
27, 26, 26, 27, 26, 26, 26, 26, 27, 27, 27, 26, 27, 27, 27, 26, 26, 26, 26, 27,
27, 27, 26, 28, 24, 19, 20, 19, 20, 20, 20, 19, 20, 20, 20, 20, 20, 20, 19, 20,
20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 19, 20, 19, 19, 20, 21, 24, 28, 27, 27,
28, 27, 28, 27, 28, 26, 37, 44, 41, 43, 42, 43, 43, 42, 42, 43, 42, 43, 43, 43,
43, 43, 43, 43, 42, 43, 43, 43, 40, 34, 35, 35, 35, 35, 35, 36, 36, 36, 36, 36,
36, 36, 36, 36, 36, 36, 36, 35, 36, 36, 36, 36, 36, 36, 36, 36, 35, 35, 35, 35,
39, 43, 43, 43, 42, 42, 42, 43, 42, 42, 42, 43, 42, 43, 42, 42, 42, 42, 43, 43,
43, 42, 44, 43, 42, 42, 44, 41, 54, 61, 59, 60, 55, 52, 52, 52, 53, 51, 52, 52,
52, 52, 52, 52, 52, 52, 52, 52, 52, 53, 51, 53, 51, 53, 51, 54, 51, 54, 49, 54,
49, 54, 49, 55, 49, -33, -37, -34, -36, -41, -37, -38, -41, -35, -41, -37, -40,
-38, -43, -40, -43, -41, -43, -42, -44, -44, -45, -44, -46, -46, -46, -46, -47,
-48, -48, -47, -51, -57, -55, -58, -56, -60, -49, -40, -42, -41, -42, -41, -42,
-42, -43, -42, -43, -43, -43, -43, -43, -43, -44, -44, -44, -45, -44, -45, -45,
-46, -45, -45, -41, -37, -38, -38, -38, -38, -38, -39, -38, -38, -39, -38, -39,
-39, -38, -38, -39, -39, -39, -39, -39, -39, -39, -39, -39, -38, -39, -39, -39,
-39, -40, -37, -43, -46, -45, -47, -45, -46, -46, -45, -46, -46, -46, -46, -46,
-45, -46, -45, -46, -47, -46, -46, -44, -47, -41, -29, -32, -30, -30, -30, -30,
-31, -30, -30, -26, -23, -23, -23, -23, -23, -23, -23, -23, -24, -22, -23, -22,
-23, -22, -22, -23, -22, -22, -22, -22, -22, -22, -22, -22, -21, -21, -21, -21,
-21, -22, -20, -25, -29, -27, -27, -27, -27, -28, -27, -27, -27, -27, -28, -27,
-27, -27, -27, -27, -26, -27, -26, -27, -27, -26, -25, -26, -26, -26, -26, -25,
-25, -25, -24, -21, -18, -18, -18, -18, -18, -17, -17, -18, -17, -17, -16, -18,
-18, -17, -17, -17, -16, -16, -16, -17, -16, -16, -16, -16, -16, -16, -15, -15,
-15, -16, -15, -19, -22, -22, -21, -22, -22, -22, -21, -21, -22, -22, -21, -21,
-21, -21, -21, -19, -21, -19, -22, -18, -23, -17, -23, -15, -26, -9, -47, -119,
-73, -55, -33, -14, };