#define DATA_LENGTH 512
#define DATA AKWF_0410

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 6, 8, 9, 11, 13, 14, 15, 16, 18,
21, 22, 25, 28, 31, 34, 37, 40, 42, 44, 47, 49, 51, 52, 54, 55, 57, 57, 60, 64,
69, 75, 81, 86, 90, 92, 91, 90, 88, 85, 82, 77, 71, 63, 57, 51, 45, 43, 42, 43,
47, 51, 56, 60, 65, 71, 75, 80, 84, 87, 90, 92, 94, 94, 94, 94, 92, 90, 87, 84,
81, 80, 79, 79, 79, 80, 80, 82, 82, 83, 82, 80, 80, 76, 74, 72, 70, 68, 65, 62,
58, 55, 52, 49, 47, 46, 45, 41, 36, 27, 16, 6, -6, -18, -29, -39, -50, -60, -70,
-78, -86, -94, -99, -105, -110, -113, -114, -113, -110, -108, -104, -99, -94,
-91, -87, -84, -82, -80, -79, -79, -78, -79, -78, -79, -79, -78, -78, -77, -76,
-73, -71, -68, -66, -62, -59, -57, -54, -52, -49, -48, -46, -43, -42, -41, -40,
-39, -36, -34, -28, -23, -17, -13, -10, -8, -8, -10, -13, -16, -18, -24, -29,
-36, -43, -50, -55, -56, -57, -54, -50, -46, -41, -35, -30, -24, -18, -13, -9,
-4, -1, 1, 3, 4, 5, 4, 3, 2, 0, -1, -2, -3, -2, -1, 2, 4, 6, 8, 12, 14, 17, 19,
20, 20, 22, 23, 24, 25, 25, 25, 25, 26, 24, 26, 26, 28, 29, 28, 23, 17, 7, -3,
-13, -23, -32, -40, -48, -55, -61, -67, -72, -76, -80, -82, -83, -83, -81, -78,
-74, -68, -61, -56, -49, -44, -38, -35, -24, -9, -5, -3, -2, 0, 0, 1, 2, 3, 3,
5, 6, 8, 10, 12, 16, 18, 20, 23, 24, 26, 28, 30, 31, 33, 34, 35, 36, 37, 39, 44,
48, 54, 60, 65, 68, 69, 69, 67, 66, 63, 58, 53, 48, 41, 35, 28, 23, 22, 24, 26,
29, 34, 40, 45, 51, 57, 62, 68, 71, 76, 79, 83, 85, 86, 87, 86, 85, 84, 82, 80,
79, 78, 77, 77, 78, 81, 81, 82, 83, 83, 83, 82, 80, 77, 74, 72, 69, 66, 63, 60,
57, 53, 50, 47, 47, 45, 43, 40, 33, 23, 14, 1, -10, -21, -32, -43, -54, -64,
-74, -84, -91, -98, -105, -111, -115, -118, -119, -118, -116, -114, -110, -107,
-103, -99, -97, -95, -93, -92, -91, -91, -92, -93, -94, -94, -96, -95, -96, -96,
-95, -93, -91, -89, -87, -84, -81, -80, -78, -77, -75, -73, -72, -72, -70, -69,
-69, -68, -66, -62, -59, -53, -47, -44, -41, -41, -42, -43, -45, -50, -55, -59,
-65, -73, -80, -86, -91, -93, -93, -91, -87, -82, -77, -71, -66, -61, -56, -50,
-46, -42, -37, -35, -32, -32, -31, -31, -32, -33, -35, -35, -35, -36, -35, -33,
-31, -28, -24, -20, -17, -14, -11, -9, -7, -5, -3, -1, 1, 2, 4, 4, 5, 6, 7, 8,
10, 12, 13, 13, 8, 2, -6, -15, -24, -33, -41, -48, -55, -61, -67, -72, -75, -79,
-81, -83, -83, -82, -80, -76, -69, -64, -57, -51, -43, -37, -31, -27, -13, 0, };