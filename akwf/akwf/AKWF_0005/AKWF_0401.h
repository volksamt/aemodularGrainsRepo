#define DATA_LENGTH 512
#define DATA AKWF_0401

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 12, 14, 15, 17, 18, 21, 23, 24,
25, 24, 23, 26, 28, 31, 34, 36, 37, 36, 37, 41, 43, 48, 52, 56, 60, 62, 65, 66,
67, 70, 75, 80, 85, 88, 91, 94, 96, 98, 100, 101, 100, 101, 101, 102, 102, 102,
101, 101, 101, 100, 101, 102, 102, 100, 98, 95, 90, 88, 87, 87, 87, 87, 86, 85,
86, 84, 81, 79, 75, 74, 73, 73, 73, 76, 78, 81, 84, 85, 86, 87, 84, 81, 77, 74,
72, 69, 66, 65, 67, 67, 68, 68, 69, 70, 71, 72, 69, 65, 62, 59, 57, 57, 60, 61,
61, 62, 61, 62, 64, 67, 70, 71, 71, 72, 73, 74, 75, 75, 77, 80, 85, 88, 90, 92,
91, 92, 91, 92, 94, 95, 94, 93, 91, 90, 87, 85, 84, 84, 85, 87, 88, 87, 90, 92,
94, 93, 92, 91, 90, 89, 90, 91, 92, 94, 97, 99, 100, 99, 100, 101, 104, 107,
111, 112, 112, 111, 112, 114, 115, 115, 113, 113, 111, 108, 106, 104, 103, 100,
98, 97, 96, 95, 95, 95, 96, 96, 97, 100, 106, 112, 115, 117, 118, 118, 119, 119,
116, 112, 109, 107, 104, 104, 103, 101, 99, 97, 95, 94, 93, 92, 91, 91, 91, 91,
92, 91, 93, 94, 97, 97, 99, 103, 105, 105, 106, 106, 107, 107, 107, 106, 107,
108, 109, 108, 109, 108, 108, 110, 107, 103, 103, 101, 98, 93, 89, 88, 87, 88,
90, 88, 92, 79, 32, 5, -5, -11, -12, -14, -15, -16, -18, -21, -23, -25, -24,
-23, -23, -26, -28, -32, -34, -35, -37, -36, -37, -41, -45, -49, -53, -57, -59,
-63, -65, -66, -67, -71, -76, -81, -85, -88, -91, -94, -96, -99, -99, -99, -100,
-101, -102, -102, -102, -102, -102, -100, -99, -101, -101, -103, -102, -100,
-97, -94, -89, -88, -88, -88, -87, -87, -86, -85, -85, -84, -82, -79, -76, -74,
-72, -72, -74, -76, -79, -82, -84, -86, -87, -87, -83, -80, -77, -75, -71, -68,
-66, -65, -67, -67, -68, -68, -69, -70, -72, -71, -69, -65, -62, -59, -57, -58,
-60, -62, -62, -61, -61, -62, -65, -67, -70, -71, -72, -72, -73, -74, -74, -76,
-77, -82, -85, -87, -90, -92, -91, -91, -91, -92, -93, -94, -94, -93, -91, -89,
-87, -84, -85, -84, -86, -86, -87, -88, -90, -92, -94, -93, -92, -90, -91, -90,
-90, -91, -92, -95, -97, -99, -99, -99, -100, -102, -105, -109, -110, -112,
-112, -111, -111, -114, -115, -115, -113, -113, -110, -108, -106, -104, -102,
-100, -98, -97, -95, -95, -95, -95, -96, -96, -98, -100, -108, -113, -116, -117,
-118, -118, -119, -119, -115, -111, -109, -106, -106, -105, -103, -100, -98,
-97, -95, -94, -92, -92, -92, -91, -91, -91, -92, -92, -93, -96, -97, -98, -99,
-102, -105, -106, -106, -106, -107, -107, -107, -106, -107, -109, -108, -108,
-109, -108, -108, -109, -107, -103, -103, -100, -97, -91, -89, -87, -87, -88,
-90, -88, -93, -74, -27, -5, };