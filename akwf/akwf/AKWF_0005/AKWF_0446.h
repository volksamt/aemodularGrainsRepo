#define DATA_LENGTH 512
#define DATA AKWF_0446

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 11, 15, 18, 21, 24, 28, 30,
33, 35, 38, 40, 43, 46, 47, 50, 52, 53, 55, 58, 60, 61, 63, 65, 67, 67, 69, 70,
72, 73, 74, 76, 78, 78, 79, 81, 82, 82, 83, 84, 84, 87, 87, 88, 89, 90, 91, 91,
91, 93, 94, 94, 95, 95, 96, 98, 97, 98, 99, 99, 100, 100, 101, 101, 103, 102,
103, 103, 104, 105, 105, 106, 106, 106, 106, 107, 107, 108, 109, 108, 110, 108,
110, 109, 110, 111, 111, 111, 111, 112, 113, 112, 113, 112, 113, 114, 114, 114,
115, 115, 114, 115, 116, 115, 116, 116, 117, 116, 117, 118, 117, 117, 117, 117,
119, 118, 119, 119, 118, 119, 120, 109, 72, 31, 5, -10, -16, -16, -15, -16, -18,
-23, -30, -37, -43, -48, -53, -57, -60, -60, -62, -61, -62, -62, -60, -59, -58,
-57, -55, -53, -52, -50, -49, -46, -45, -42, -40, -37, -36, -32, -30, -26, -23,
-20, -17, -13, -9, -7, -2, 2, 6, 10, 13, 16, 19, 22, 26, 29, 32, 34, 37, 39, 42,
44, 46, 48, 51, 53, 55, 56, 59, 60, 62, 63, 66, 67, 69, 70, 71, 72, 73, 75, 77,
77, 78, 80, 81, 82, 83, 84, 84, 85, 86, 88, 89, 89, 90, 91, 91, 92, 93, 94, 95,
95, 96, 97, 97, 98, 98, 99, 99, 99, 101, 101, 102, 103, 103, 103, 103, 104, 105,
105, 106, 106, 107, 106, 107, 107, 108, 80, 24, -13, -38, -52, -59, -64, -68,
-71, -75, -78, -82, -86, -89, -91, -94, -96, -97, -98, -98, -100, -100, -99,
-99, -101, -100, -99, -99, -98, -98, -98, -97, -97, -96, -96, -96, -95, -94,
-93, -92, -93, -91, -90, -90, -89, -89, -88, -87, -87, -85, -85, -83, -82, -81,
-80, -79, -78, -76, -74, -74, -72, -71, -70, -68, -67, -65, -63, -63, -61, -59,
-56, -55, -53, -51, -49, -47, -45, -43, -40, -37, -35, -31, -28, -26, -22, -19,
-16, -12, -8, -5, -1, 3, 7, 10, 14, 18, 21, 24, 27, 30, 32, 35, 38, 41, 43, 44,
48, 49, 51, 54, 55, 57, 60, 61, 63, 64, 66, 67, 70, 69, 72, 73, 74, 75, 77, 77,
80, 75, 17, -29, -53, -70, -78, -84, -89, -92, -95, -98, -99, -102, -104, -107,
-108, -110, -111, -112, -113, -114, -114, -114, -114, -114, -114, -115, -114,
-114, -115, -114, -114, -114, -114, -113, -113, -112, -113, -113, -112, -113,
-112, -112, -112, -111, -111, -110, -110, -110, -109, -110, -109, -108, -109,
-108, -107, -107, -108, -107, -106, -106, -105, -104, -103, -104, -103, -104,
-102, -101, -101, -101, -100, -99, -99, -99, -99, -97, -97, -96, -96, -95, -94,
-94, -94, -92, -91, -90, -89, -89, -88, -88, -87, -85, -85, -83, -83, -82, -81,
-79, -78, -77, -77, -74, -74, -72, -71, -69, -68, -66, -64, -64, -62, -59, -58,
-56, -54, -52, -50, -49, -46, -44, -42, -38, -36, -34, -30, -28, -25, -21, -18,
-14, -10, -7, -3, };