#define DATA_LENGTH 512
#define DATA AKWF_0437

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 7, 9, 10, 13, 15, 17, 19, 20,
23, 25, 26, 29, 30, 32, 34, 35, 38, 39, 42, 43, 44, 47, 48, 50, 51, 53, 54, 57,
59, 59, 61, 62, 65, 66, 67, 70, 70, 72, 74, 75, 76, 77, 79, 80, 82, 83, 84, 86,
87, 88, 90, 90, 92, 92, 94, 95, 95, 97, 99, 99, 100, 100, 102, 102, 103, 104,
105, 107, 107, 108, 108, 109, 109, 110, 112, 112, 111, 113, 113, 113, 114, 114,
115, 115, 115, 116, 116, 116, 117, 118, 118, 117, 118, 118, 118, 118, 118, 117,
118, 118, 118, 118, 117, 118, 118, 117, 117, 117, 116, 117, 117, 116, 115, 115,
114, 114, 113, 114, 113, 112, 112, 111, 110, 110, 109, 108, 108, 107, 106, 105,
104, 103, 102, 102, 101, 100, 99, 98, 97, 95, 95, 93, 92, 91, 90, 89, 88, 87,
86, 85, 82, 82, 80, 79, 78, 76, 74, 73, 73, 70, 69, 67, 66, 65, 63, 61, 60, 58,
57, 55, 53, 52, 50, 48, 46, 44, 43, 40, 40, 37, 35, 33, 32, 30, 28, 27, 24, 23,
21, 18, 16, 15, 13, 11, 9, 6, 5, 3, 1, -1, -4, -6, -10, -13, -16, -19, -23, -28,
-32, -37, -42, -48, -54, -59, -65, -71, -78, -85, -91, -98, -103, -108, -109,
-104, -87, -41, 29, 91, 117, 118, 108, 101, 96, 91, 85, 77, 71, 65, 59, 53, 47,
42, 36, 32, 27, 23, 19, 15, 11, 9, 6, 4, 1, -2, -2, -6, -7, -9, -11, -13, -14,
-17, -19, -21, -22, -25, -27, -28, -31, -33, -34, -36, -38, -40, -42, -42, -45,
-46, -49, -49, -52, -53, -55, -57, -58, -60, -61, -62, -64, -65, -68, -69, -71,
-73, -73, -75, -76, -77, -79, -80, -81, -84, -85, -86, -86, -89, -89, -91, -91,
-93, -94, -95, -96, -97, -98, -99, -100, -100, -102, -103, -103, -104, -106,
-105, -107, -108, -108, -109, -110, -110, -112, -111, -112, -112, -114, -114,
-114, -114, -116, -115, -115, -116, -117, -116, -117, -117, -118, -117, -117,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -117, -117, -116, -116, -116, -115, -114, -115, -114, -114, -113, -113,
-112, -112, -111, -111, -110, -109, -108, -107, -106, -106, -105, -104, -103,
-102, -102, -100, -100, -98, -98, -97, -95, -95, -93, -93, -91, -90, -88, -87,
-86, -85, -85, -83, -81, -80, -79, -78, -75, -74, -73, -72, -70, -69, -67, -65,
-63, -63, -61, -59, -58, -56, -55, -52, -52, -49, -48, -46, -45, -43, -40, -39,
-37, -35, -33, -32, -31, -28, -26, -24, -22, -20, -19, -16, -14, -12, -11, -9,
-6, -4, -2, 0, 1, 4, 7, 9, 14, 16, 19, 24, 28, 32, 38, 43, 48, 53, 59, 66, 72,
79, 86, 93, 98, 104, 107, 109, 103, 83, 33, -38, -95, -119, -117, -107, -100,
-96, -90, -84, -77, -71, -64, -57, -51, -46, -41, -35, -32, -26, -22, -19, -16,
-12, -8, -6, -3, -1, };