#define DATA_LENGTH 512
#define DATA AKWF_0454

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 6, 6, 6, 6, 6, 3, 3, 2, 2, 4, 5,
5, 5, 5, 4, 4, 3, 3, 4, 7, 15, 24, 30, 30, 25, 19, 17, 19, 24, 29, 33, 38, 42,
45, 50, 53, 55, 58, 61, 64, 67, 69, 71, 73, 76, 79, 80, 82, 84, 86, 87, 89, 91,
92, 93, 95, 95, 96, 97, 99, 100, 100, 101, 102, 103, 104, 104, 105, 106, 106,
107, 107, 108, 109, 109, 110, 110, 111, 111, 111, 112, 112, 113, 113, 114, 114,
114, 114, 114, 115, 115, 115, 115, 116, 117, 116, 115, 116, 116, 117, 117, 118,
117, 117, 117, 118, 118, 117, 119, 118, 118, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 118, 119, 118, 118, 119, 119, 119, 118, 118, 119, 119, 119, 118,
119, 119, 119, 119, 118, 119, 120, 119, 119, 118, 119, 119, 118, 117, 118, 119,
118, 118, 118, 117, 118, 118, 118, 117, 117, 116, 117, 117, 116, 116, 116, 115,
116, 115, 115, 115, 114, 115, 115, 114, 113, 112, 112, 113, 113, 112, 111, 111,
110, 110, 109, 109, 108, 108, 107, 107, 107, 106, 105, 104, 103, 103, 102, 100,
100, 100, 98, 98, 97, 96, 94, 92, 91, 90, 89, 87, 85, 83, 82, 80, 77, 76, 73,
70, 67, 63, 60, 56, 53, 49, 43, 39, 39, 42, 46, 47, 42, 34, 24, 18, 14, 13, 12,
13, 13, 13, 12, 12, 12, 11, 10, 8, 9, 11, 12, 11, 11, 12, 12, 8, 0, -6, -7, -6,
-7, -6, -6, -4, -3, -2, -2, -3, -5, -5, -5, -4, -4, -4, -3, -3, -4, -8, -16,
-25, -30, -30, -24, -19, -18, -20, -24, -30, -34, -39, -43, -46, -49, -53, -56,
-59, -61, -64, -67, -69, -72, -74, -77, -78, -81, -82, -84, -85, -87, -89, -90,
-92, -93, -95, -96, -97, -98, -99, -100, -101, -102, -103, -103, -104, -104,
-105, -106, -106, -107, -107, -109, -108, -110, -109, -111, -111, -111, -111,
-112, -111, -112, -113, -113, -113, -113, -115, -115, -115, -115, -114, -116,
-116, -117, -116, -116, -116, -116, -117, -117, -117, -117, -118, -117, -118,
-117, -118, -118, -118, -119, -118, -118, -118, -119, -118, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -120, -119, -118, -120, -119, -119, -119,
-119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -118, -119, -118,
-119, -119, -118, -118, -118, -119, -118, -118, -118, -117, -117, -117, -117,
-117, -116, -117, -116, -116, -116, -116, -115, -116, -115, -115, -115, -115,
-114, -114, -114, -114, -113, -113, -112, -112, -111, -111, -111, -111, -110,
-109, -109, -109, -108, -107, -107, -106, -106, -105, -104, -103, -103, -102,
-101, -100, -100, -98, -97, -97, -95, -94, -93, -91, -90, -88, -87, -86, -83,
-81, -79, -77, -75, -72, -69, -67, -63, -60, -56, -52, -47, -43, -39, -39, -43,
-47, -46, -42, -33, -23, -17, -14, -14, -13, -13, -12, -13, -13, -13, -12, -10,
-8, -9, -10, -11, -12, -11, -11, -13, -12, -6, };