#define DATA_LENGTH 512
#define DATA AKWF_0439

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 7, 9, 11, 13, 14, 17, 19,
21, 23, 24, 27, 28, 30, 33, 34, 36, 37, 39, 41, 43, 45, 46, 48, 50, 52, 53, 56,
56, 58, 60, 62, 63, 65, 66, 67, 70, 71, 72, 73, 75, 76, 78, 79, 80, 81, 83, 85,
86, 87, 89, 89, 90, 92, 93, 94, 95, 96, 97, 99, 99, 101, 102, 102, 102, 104,
105, 105, 107, 107, 109, 109, 109, 110, 111, 112, 112, 113, 113, 114, 114, 115,
116, 116, 116, 116, 116, 117, 117, 118, 118, 117, 118, 118, 118, 119, 119, 119,
118, 120, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 117, 118, 117, 116,
117, 116, 115, 115, 115, 114, 113, 113, 113, 112, 111, 111, 111, 109, 108, 108,
106, 105, 105, 105, 104, 103, 101, 100, 99, 98, 97, 96, 95, 94, 93, 93, 91, 89,
89, 87, 87, 85, 83, 83, 81, 80, 78, 77, 75, 74, 73, 71, 69, 69, 67, 65, 64, 62,
60, 59, 57, 55, 54, 52, 51, 48, 47, 45, 44, 42, 40, 39, 36, 35, 33, 31, 29, 26,
25, 24, 21, 20, 17, 15, 14, 11, 10, 8, 6, 4, 1, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, -1, 1, -1, 0, 1, 1, 0, 2, 6, 3, -3, -7, -4, 0, 1, 0, 0,
-1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -2, -2, -5, -7, -9,
-11, -12, -15, -18, -19, -21, -23, -25, -27, -28, -31, -33, -33, -36, -38, -39,
-41, -44, -45, -47, -48, -50, -51, -54, -55, -57, -59, -60, -61, -63, -65, -67,
-67, -69, -71, -72, -74, -75, -77, -77, -79, -81, -82, -83, -85, -86, -87, -88,
-89, -91, -92, -93, -94, -96, -97, -97, -97, -100, -101, -102, -102, -103, -104,
-105, -106, -107, -107, -109, -109, -110, -110, -111, -112, -112, -113, -114,
-113, -114, -114, -115, -115, -116, -117, -117, -116, -117, -117, -118, -118,
-118, -118, -119, -118, -119, -119, -119, -119, -120, -119, -118, -118, -119,
-118, -118, -119, -119, -118, -118, -118, -116, -116, -116, -115, -115, -115,
-114, -114, -113, -113, -112, -112, -111, -110, -110, -109, -108, -107, -107,
-106, -104, -104, -103, -103, -102, -100, -99, -99, -98, -96, -95, -94, -93,
-92, -90, -90, -89, -87, -86, -84, -84, -82, -82, -79, -78, -78, -76, -74, -73,
-71, -69, -68, -66, -65, -63, -62, -60, -59, -57, -55, -53, -52, -51, -49, -47,
-45, -43, -41, -40, -38, -36, -34, -32, -31, -29, -27, -25, -23, -21, -19, -18,
-16, -13, -12, -10, -7, -6, -3, -2, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, -1, 0, -1, 0, 0, 0, 0, 0, -4, -5, -3, 5, 6, 2, 0, -1, -1, 0, 0, 1, 0, 0,
0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, };