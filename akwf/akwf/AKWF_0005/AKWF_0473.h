#define DATA_LENGTH 512
#define DATA AKWF_0473

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 1, 0, -1,
0, 1, 0, 1, 0, 1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0,
-1, 0, -1, 0, 0, -1, 1, -1, 0, 0, 1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 1, -1, 0, 0, 0, 1, -1, 1, 0,
0, -1, 0, -1, -1, 0, -1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
1, 3, 9, 17, 22, 24, 25, 26, 27, 29, 31, 33, 34, 35, 37, 39, 41, 42, 42, 43, 44,
45, 46, 46, 47, 47, 47, 49, 48, 49, 49, 50, 49, 50, 49, 49, 49, 49, 49, 49, 49,
49, 48, 48, 48, 48, 48, 48, 47, 48, 48, 47, 47, 46, 47, 47, 46, 46, 45, 46, 45,
44, 45, 44, 44, 45, 45, 44, 44, 45, 43, 44, 44, 44, 44, 44, 43, 43, 43, 43, 43,
43, 44, 44, 43, 44, 43, 43, 44, 44, 43, 45, 44, 44, 44, 45, 44, 44, 45, 45, 45,
45, 46, 46, 46, 47, 47, 47, 47, 48, 49, 49, 49, 49, 51, 51, 50, 51, 52, 53, 53,
54, 53, 55, 55, 55, 56, 56, 58, 58, 58, 57, 46, 16, -17, -36, -34, -25, -20,
-26, -38, -48, -50, -48, -48, -48, -51, -54, -56, -58, -59, -59, -60, -60, -60,
-60, -61, -60, -59, -59, -59, -58, -58, -57, -56, -56, -56, -55, -54, -54, -52,
-52, -51, -50, -50, -50, -48, -48, -48, -47, -47, -47, -46, -46, -46, -44, -45,
-44, -44, -44, -43, -44, -43, -43, -43, -43, -43, -43, -43, -43, -43, -44, -44,
-43, -43, -43, -44, -43, -44, -44, -43, -43, -43, -44, -44, -45, -44, -44, -45,
-44, -45, -45, -45, -45, -45, -45, -45, -46, -45, -46, -45, -45, -46, -46, -45,
-45, -45, -45, -45, -45, -45, -44, -45, -43, -45, -43, -43, -43, -42, -42, -42,
-40, -40, -39, -38, -38, -36, -35, -34, -32, -30, -27, -25, -20, -16, -9, -4,
-1, -1, -4, -5, -4, -3, -1, 1, 1, 2, 2, 2, 3, 3, 4, 4, 4, 5, 4, 5, 5, 4, 5, 4,
4, 4, 4, 4, 3, 4, 2, 2, 2, 3, 2, 2, 2, 3, 2, 2, 1, 2, 2, 1, 1, 0, 1, 1, 0, 1, 0,
1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, -1, 0, 0,
0, 0, -1, -1, 0, 0, -1, 0, 1, 0, 0, 1, 0, -1, -1, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, };