#define DATA_LENGTH 512
#define DATA AKWF_0498

const PROGMEM int8_t DATA[DATA_LENGTH] = {42, 51, 46, 49, 47, 49, 48, 49, 49,
49, 48, 49, 48, 49, 48, 49, 49, 48, 49, 49, 48, 49, 48, 48, 49, 49, 48, 48, 49,
48, 48, 48, 49, 49, 49, 48, 49, 49, 49, 49, 49, 49, 48, 48, 48, 49, 48, 48, 48,
49, 49, 49, 48, 48, 49, 49, 48, 49, 48, 49, 49, 48, 48, 49, 49, 49, 49, 48, 48,
49, 49, 49, 48, 48, 48, 48, 48, 48, 49, 49, 48, 48, 48, 48, 48, 48, 48, 49, 48,
49, 48, 47, 49, 48, 48, 48, 48, 48, 48, 47, 48, 48, 48, 48, 48, 48, 48, 48, 48,
48, 48, 48, 48, 48, 48, 48, 48, 49, 48, 48, 48, 48, 48, 48, 49, 48, 47, 48, 49,
48, 48, 48, 47, 48, 48, 48, 48, 48, 47, 48, 48, 49, 48, 47, 48, 47, 47, 47, 47,
48, 47, 47, 48, 47, 47, 49, 47, 47, 48, 48, 47, 48, 48, 47, 48, 48, 48, 48, 48,
48, 48, 48, 47, 47, 48, 47, 48, 48, 48, 48, 48, 47, 48, 47, 48, 48, 48, 47, 47,
47, 48, 48, 48, 48, 48, 48, 48, 48, 47, 47, 47, 47, 48, 47, 47, 47, 48, 48, 48,
47, 48, 47, 47, 48, 47, 47, 48, 47, 48, 47, 48, 47, 47, 48, 47, 47, 47, 47, 48,
48, 48, 48, 47, 47, 47, 46, 48, 47, 48, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47,
48, 47, 47, 47, 47, 47, 47, 48, 47, 47, 47, 47, 47, 47, 47, 48, 47, 48, 47, 48,
47, 47, 46, 48, 47, 47, 46, 48, 47, 47, 47, 47, 47, 45, 48, 45, 49, 42, 56, -4,
-46, -31, -40, -33, -38, -35, -38, -35, -37, -36, -36, -36, -37, -36, -36, -36,
-36, -37, -36, -36, -37, -36, -36, -37, -36, -36, -36, -37, -37, -36, -36, -36,
-36, -36, -36, -36, -36, -36, -37, -35, -37, -36, -36, -36, -37, -36, -37, -36,
-37, -36, -37, -36, -36, -36, -36, -37, -36, -36, -35, -38, -34, -37, -34, -39,
-32, -41, -27, -67, -128, -115, -121, -118, -120, -119, -120, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118,
-120, -120, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118,
-119, -118, -119, -118, -118, -119, -118, -118, -118, -119, -118, -118, -117,
-119, -116, -121, -116, -122, -113, -128, -81, -25, -40, -32, -37, -34, -37,
-35, -35, -35, -35, -35, -35, -35, -34, -35, -34, -36, -34, -35, -34, -35, -34,
-34, -35, -35, -35, -36, -35, -36, -35, -36, -34, -35, -34, -35, -36, -34, -35,
-35, -35, -35, -36, -34, -35, -35, -35, -35, -35, -34, -35, -35, -35, -35, -34,
-35, -34, -35, -35, -36, -35, -34, -35, -35, -35, -34, -34, -35, -35, -34, -35,
-34, -35, -34, -35, -35, -35, -34, -35, -33, -36, -34, -35, -34, -37, -30, };