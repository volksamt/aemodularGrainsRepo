#define DATA_LENGTH 512
#define DATA AKWF_0462

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 23, 35, 46, 55, 65, 76, 86, 96,
105, 112, 117, 119, 119, 116, 113, 111, 110, 107, 106, 104, 102, 99, 94, 90, 85,
80, 74, 69, 63, 56, 50, 45, 39, 36, 32, 29, 26, 23, 19, 13, 9, 4, 1, -2, -3, -6,
-7, -7, -8, -8, -10, -11, -14, -16, -19, -21, -23, -23, -23, -24, -24, -26, -27,
-27, -28, -28, -28, -28, -28, -28, -29, -27, -27, -25, -23, -22, -20, -19, -18,
-15, -14, -12, -11, -7, -6, -4, -3, 0, 2, 4, 6, 7, 9, 11, 12, 13, 14, 16, 18,
18, 17, 18, 17, 17, 19, 20, 25, 27, 29, 30, 28, 27, 25, 23, 22, 22, 21, 20, 21,
20, 20, 19, 18, 17, 14, 11, 9, 7, 6, 5, 5, 4, 3, 2, 1, 1, 0, 0, -1, -3, -6, -9,
-13, -16, -18, -20, -21, -21, -20, -18, -18, -17, -16, -16, -14, -14, -15, -15,
-16, -17, -16, -15, -12, -9, -7, -6, -5, -5, -8, -8, -9, -9, -7, -7, -6, -4, -2,
-1, 1, 2, 0, -2, -5, -6, -6, -6, -5, -3, -3, -4, -6, -6, -6, -6, -5, -4, -5, -6,
-7, -7, -6, -5, -4, -2, -1, 0, 0, 0, 0, 0, 1, 1, 2, 1, 2, 3, 4, 3, 3, 3, 3, 3,
4, 2, 2, 3, 2, 0, -2, -7, -11, -13, -11, -5, 4, 12, 17, 18, 16, 11, 6, 1, -1,
-2, -2, -1, 0, 3, 3, 4, 4, 5, 6, 10, 11, 14, 15, 12, 9, 2, -2, -7, -10, -11,
-12, -12, -15, -19, -22, -25, -28, -27, -26, -25, -26, -28, -31, -35, -39, -41,
-41, -42, -43, -43, -46, -48, -51, -53, -54, -54, -53, -52, -50, -49, -48, -47,
-48, -48, -46, -43, -40, -38, -33, -30, -26, -21, -18, -15, -14, -12, -12, -10,
-8, -6, -3, 0, 2, 3, 2, 4, 5, 6, 9, 9, 9, 9, 9, 9, 9, 11, 12, 12, 14, 14, 14,
14, 15, 15, 14, 14, 15, 14, 14, 14, 14, 14, 13, 13, 12, 11, 11, 10, 10, 8, 7, 5,
4, 0, -3, -5, -5, -3, 1, 4, 6, 6, 6, 2, 0, -3, -5, -5, -7, -7, -7, -7, -7, -7,
-8, -10, -11, -14, -16, -18, -17, -18, -18, -16, -16, -16, -15, -14, -13, -14,
-13, -12, -13, -14, -16, -16, -16, -15, -14, -13, -12, -10, -8, -5, -4, -1, 0,
1, 1, 2, 2, 2, 4, 5, 8, 10, 12, 13, 13, 14, 13, 13, 11, 11, 13, 14, 15, 15, 17,
17, 17, 17, 16, 15, 13, 12, 11, 11, 12, 13, 11, 10, 9, 9, 9, 9, 9, 8, 7, 7, 6,
6, 6, 7, 7, 8, 8, 9, 8, 9, 8, 9, 9, 9, 8, 9, 8, 8, 8, 9, 9, 8, 8, 8, 8, 7, 7, 4,
-2, -12, -27, -45, -61, -73, -75, -69, -58, -46, -39, -37, -41, -50, -59, -68,
-77, -81, -84, -82, -78, -71, -63, -53, -44, -34, -24, -11, -1, };