#define DATA_LENGTH 512
#define DATA AKWF_0407

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 5, 6, 8, 8, 11, 12, 13, 15,
17, 18, 20, 21, 23, 24, 26, 28, 29, 30, 33, 34, 36, 37, 38, 40, 42, 43, 45, 47,
47, 48, 50, 51, 53, 53, 54, 56, 56, 57, 59, 59, 60, 61, 62, 64, 64, 65, 66, 67,
67, 67, 68, 69, 70, 71, 72, 73, 75, 76, 76, 77, 78, 79, 80, 80, 82, 83, 85, 85,
85, 88, 88, 89, 91, 92, 92, 94, 95, 96, 97, 98, 99, 99, 100, 101, 102, 102, 103,
103, 104, 104, 105, 106, 105, 106, 106, 106, 106, 105, 106, 106, 105, 106, 106,
105, 105, 104, 104, 104, 103, 104, 102, 101, 101, 100, 98, 97, 97, 95, 93, 90,
89, 87, 85, 83, 82, 78, 76, 73, 72, 69, 66, 63, 61, 58, 56, 53, 50, 47, 45, 42,
39, 36, 34, 31, 29, 26, 22, 20, 16, 14, 12, 10, 7, 6, 4, 1, 0, -2, -3, -6, -7,
-9, -11, -12, -14, -15, -16, -17, -18, -19, -21, -22, -22, -24, -25, -26, -27,
-27, -28, -28, -29, -29, -30, -30, -30, -29, -29, -30, -31, -29, -29, -29, -30,
-29, -28, -28, -27, -27, -26, -25, -25, -24, -23, -23, -22, -21, -19, -19, -18,
-18, -15, -15, -12, -10, -10, -7, -5, -4, -2, 0, 2, 4, 6, 8, 9, 11, 13, 15, 17,
19, 21, 22, 24, 27, 28, 29, 31, 32, 33, 34, 36, 37, 38, 39, 41, 41, 42, 43, 43,
44, 44, 44, 46, 45, 45, 46, 46, 46, 45, 45, 46, 45, 45, 44, 44, 44, 43, 43, 44,
43, 43, 44, 43, 44, 44, 44, 44, 43, 44, 43, 43, 44, 43, 43, 44, 43, 43, 43, 43,
43, 43, 42, 42, 41, 42, 40, 39, 39, 39, 37, 36, 36, 34, 33, 32, 31, 30, 28, 27,
25, 24, 23, 21, 20, 18, 17, 15, 13, 11, 9, 8, 6, 4, 2, 1, -1, -2, -3, -5, -7,
-8, -10, -11, -12, -13, -14, -16, -18, -19, -20, -22, -23, -24, -25, -26, -27,
-28, -30, -30, -32, -32, -33, -35, -36, -37, -39, -40, -41, -42, -44, -45, -46,
-47, -49, -51, -53, -55, -56, -58, -61, -63, -65, -67, -69, -70, -72, -76, -77,
-79, -82, -84, -86, -89, -90, -92, -94, -96, -97, -99, -101, -103, -104, -105,
-107, -108, -109, -110, -112, -112, -114, -114, -115, -116, -116, -117, -117,
-117, -117, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -118, -118, -119, -118, -118, -118, -117, -117, -116, -116,
-116, -115, -114, -114, -114, -114, -112, -112, -111, -110, -110, -109, -108,
-107, -105, -104, -103, -102, -100, -99, -98, -96, -94, -92, -91, -88, -87, -85,
-83, -80, -79, -76, -74, -71, -69, -67, -64, -62, -60, -56, -54, -52, -49, -47,
-44, -42, -40, -37, -36, -34, -33, -31, -29, -28, -27, -24, -22, -21, -20, -19,
-17, -17, -15, -14, -13, -12, -11, -9, -9, -8, -7, -6, -5, -4, -3, -2, 0, };