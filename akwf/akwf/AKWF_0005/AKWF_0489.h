#define DATA_LENGTH 512
#define DATA AKWF_0489

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 14, 19, 17, 15, 17, 21, 25, 26, 32,
47, 68, 87, 95, 98, 101, 102, 104, 108, 108, 109, 110, 111, 112, 112, 111, 112,
112, 113, 112, 113, 113, 113, 113, 113, 113, 113, 112, 113, 113, 113, 112, 112,
112, 112, 112, 112, 113, 112, 111, 111, 111, 112, 111, 113, 112, 113, 112, 111,
112, 113, 112, 112, 113, 114, 113, 114, 113, 112, 113, 113, 110, 96, 55, 13, 20,
56, 68, 67, 65, 42, 11, -16, -45, -78, -103, -113, -113, -111, -111, -112, -113,
-112, -110, -107, -104, -101, -98, -97, -96, -96, -95, -94, -93, -93, -93, -93,
-95, -96, -99, -102, -104, -106, -107, -111, -111, -112, -113, -112, -112, -109,
-103, -93, -71, -43, -20, -12, -8, -1, 12, 21, 25, 31, 49, 75, 94, 103, 105,
105, 106, 109, 109, 110, 110, 110, 110, 110, 110, 109, 109, 108, 107, 105, 103,
99, 95, 89, 80, 67, 47, 28, 21, 21, 21, 20, 16, 15, 13, 14, 16, 17, 16, 12, 9,
7, 8, 12, 15, 18, 17, 15, 14, 15, 17, 19, 22, 25, 28, 37, 56, 79, 93, 100, 102,
104, 106, 110, 110, 112, 112, 113, 113, 113, 112, 113, 112, 113, 113, 112, 112,
112, 113, 112, 112, 112, 113, 113, 113, 113, 113, 113, 112, 113, 112, 112, 111,
111, 109, 108, 107, 105, 103, 100, 97, 92, 88, 83, 77, 69, 59, 43, 27, 21, 23,
26, 28, 27, 27, 25, 25, 26, 32, 46, 64, 75, 81, 86, 89, 93, 97, 100, 103, 104,
107, 108, 109, 111, 111, 112, 112, 112, 112, 113, 113, 113, 113, 113, 113, 112,
113, 112, 113, 113, 112, 113, 113, 113, 113, 113, 113, 113, 112, 112, 113, 112,
112, 112, 112, 111, 111, 110, 110, 110, 109, 108, 107, 106, 106, 104, 103, 103,
102, 101, 100, 100, 101, 100, 100, 100, 100, 101, 102, 102, 103, 104, 106, 105,
98, 62, -11, -71, -59, -15, 4, 1, -8, -32, -68, -101, -118, -118, -113, -108,
-107, -107, -106, -101, -96, -89, -80, -71, -63, -57, -54, -53, -53, -55, -57,
-60, -66, -70, -73, -73, -68, -62, -55, -53, -56, -60, -66, -71, -77, -82, -87,
-93, -97, -102, -105, -108, -109, -112, -113, -113, -113, -111, -109, -106,
-102, -93, -82, -62, -38, -22, -18, -20, -20, -19, -16, -15, -15, -15, -15, -16,
-16, -17, -18, -19, -21, -24, -25, -27, -34, -52, -73, -88, -96, -98, -101,
-104, -106, -107, -109, -110, -111, -111, -112, -113, -112, -112, -113, -112,
-112, -112, -112, -112, -112, -111, -110, -110, -108, -105, -104, -100, -96,
-89, -79, -61, -38, -23, -18, -20, -18, -16, -14, -12, -3, 10, 17, 17, 16, 16,
17, 20, 23, 23, 24, 25, 25, 26, 26, 25, 25, 24, 24, 23, 22, 20, 18, 16, 16, 15,
14, 15, 14, 9, -4, -14, -19, -17, -14, -14, -15, -17, -17, -19, -19, -20, -20,
-20, -21, -21, -20, -19, -19, -18, -16, -16, -14, -15, -15, -15, -8, };