#define DATA_LENGTH 512
#define DATA AKWF_0429

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 9, 13, 18, 24, 30, 37, 43, 48,
52, 54, 55, 54, 55, 56, 61, 70, 78, 79, 80, 87, 95, 101, 105, 104, 105, 104,
104, 103, 104, 105, 105, 105, 105, 105, 106, 107, 109, 114, 117, 119, 115, 105,
97, 91, 84, 70, 54, 45, 41, 29, 19, 17, 19, 19, 21, 27, 32, 36, 43, 49, 52, 55,
58, 58, 56, 54, 52, 48, 45, 42, 39, 36, 33, 31, 27, 23, 18, 13, 7, 2, -3, -8,
-12, -17, -21, -25, -30, -33, -38, -41, -45, -48, -52, -54, -57, -59, -61, -63,
-64, -66, -67, -67, -68, -68, -69, -68, -67, -67, -67, -65, -64, -64, -62, -62,
-60, -58, -56, -54, -54, -54, -51, -50, -49, -46, -44, -42, -40, -37, -35, -33,
-33, -32, -32, -36, -41, -47, -54, -58, -61, -63, -65, -70, -75, -81, -82, -78,
-71, -62, -56, -50, -43, -36, -29, -20, -11, 1, 12, 23, 34, 40, 44, 46, 49, 50,
52, 54, 56, 55, 55, 54, 50, 46, 41, 35, 31, 26, 22, 18, 13, 8, 4, 1, 0, -1, -1,
2, 4, 7, 10, 14, 17, 21, 23, 25, 28, 29, 32, 33, 35, 36, 38, 39, 39, 40, 41, 42,
40, 41, 41, 40, 40, 40, 38, 37, 36, 35, 34, 33, 31, 29, 27, 26, 24, 21, 19, 17,
16, 14, 11, 9, 8, 5, 3, 2, -1, -2, -3, -5, -7, -9, -11, -12, -13, -14, -17, -16,
-18, -19, -20, -20, -21, -21, -21, -23, -22, -22, -23, -23, -23, -23, -22, -21,
-20, -20, -20, -21, -20, -21, -21, -18, -13, -5, 5, 9, 12, 16, 20, 25, 31, 34,
37, 38, 38, 38, 42, 43, 34, 23, 17, 11, 5, -2, -12, -22, -29, -35, -40, -42,
-45, -44, -42, -39, -34, -28, -19, -6, 7, 12, 13, 21, 27, 29, 28, 27, 26, 27,
26, 25, 21, 15, 7, 0, -5, -9, -12, -15, -18, -20, -23, -25, -27, -29, -29, -30,
-29, -29, -27, -27, -27, -27, -27, -27, -27, -28, -27, -28, -28, -28, -29, -29,
-29, -30, -30, -32, -33, -33, -34, -35, -35, -35, -35, -34, -34, -32, -30, -28,
-23, -19, -12, -5, 1, 7, 11, 15, 18, 20, 21, 24, 26, 29, 31, 31, 30, 26, 22, 16,
11, 6, 2, -3, -10, -16, -23, -30, -38, -46, -53, -61, -70, -75, -80, -81, -83,
-84, -85, -86, -87, -87, -86, -86, -84, -82, -80, -80, -76, -74, -72, -70, -65,
-62, -57, -52, -47, -44, -39, -36, -34, -33, -33, -34, -35, -36, -37, -38, -39,
-40, -41, -42, -42, -44, -44, -45, -46, -47, -47, -47, -48, -47, -46, -45, -45,
-42, -41, -40, -37, -36, -33, -30, -28, -25, -22, -19, -15, -12, -9, -6, -2, 1,
5, 8, 11, 15, 17, 21, 24, 27, 30, 32, 36, 38, 40, 42, 44, 46, 47, 49, 51, 53,
54, 55, 56, 57, 58, 59, 59, 60, 60, 60, 60, 60, 57, 54, 48, 40, 30, 25, 22, 16,
5, -2, };