#define DATA_LENGTH 512
#define DATA AKWF_0461

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 14, 24, 35, 45, 55, 65, 75, 83, 90,
97, 104, 109, 113, 117, 118, 119, 119, 117, 115, 111, 106, 101, 94, 88, 80, 72,
63, 54, 45, 35, 26, 17, 8, -1, -9, -17, -24, -30, -38, -43, -47, -51, -56, -58,
-60, -62, -63, -63, -63, -62, -62, -60, -59, -58, -55, -52, -50, -47, -45, -43,
-39, -37, -35, -32, -30, -27, -24, -22, -20, -17, -14, -12, -9, -6, -4, -1, 2,
5, 8, 11, 14, 17, 19, 23, 26, 29, 32, 34, 38, 40, 42, 44, 46, 47, 48, 50, 51,
51, 51, 50, 50, 48, 48, 45, 42, 41, 37, 34, 30, 27, 23, 19, 15, 10, 6, 1, -3,
-7, -12, -16, -20, -23, -28, -30, -33, -36, -38, -39, -40, -42, -43, -44, -44,
-44, -44, -43, -42, -41, -40, -39, -37, -35, -33, -31, -28, -25, -22, -21, -17,
-14, -12, -9, -5, -3, 0, 2, 5, 8, 11, 13, 16, 18, 19, 22, 24, 25, 26, 28, 30,
30, 31, 32, 33, 32, 33, 32, 31, 31, 31, 29, 28, 27, 26, 23, 21, 20, 17, 14, 12,
9, 7, 5, 3, 0, -3, -5, -6, -9, -11, -12, -14, -15, -16, -17, -19, -19, -20, -20,
-21, -21, -20, -19, -19, -18, -18, -16, -15, -14, -12, -11, -11, -10, -8, -7,
-4, -2, 0, 2, 4, 7, 8, 10, 12, 14, 17, 18, 20, 21, 22, 24, 25, 26, 27, 29, 30,
31, 33, 33, 34, 35, 35, 35, 34, 34, 32, 31, 29, 29, 26, 23, 20, 18, 16, 12, 9,
6, 3, 0, -5, -8, -11, -15, -19, -23, -26, -29, -32, -36, -39, -41, -43, -47,
-48, -50, -52, -53, -54, -54, -55, -54, -54, -53, -52, -50, -48, -46, -43, -41,
-36, -34, -31, -26, -23, -18, -14, -10, -6, -1, 3, 6, 10, 14, 16, 20, 23, 25,
29, 30, 32, 34, 35, 36, 37, 38, 38, 37, 38, 38, 36, 35, 34, 33, 32, 29, 28, 27,
25, 23, 20, 19, 16, 15, 13, 10, 9, 6, 4, 2, -1, -3, -5, -7, -9, -10, -12, -14,
-15, -16, -16, -18, -18, -20, -20, -22, -21, -22, -22, -22, -22, -21, -21, -21,
-21, -21, -20, -20, -18, -18, -17, -16, -15, -13, -12, -12, -10, -9, -7, -6, -5,
-4, -3, -1, 0, 1, 2, 4, 4, 6, 7, 7, 9, 10, 11, 12, 13, 13, 14, 15, 15, 15, 16,
16, 16, 16, 16, 17, 15, 16, 15, 15, 14, 13, 13, 12, 11, 10, 9, 8, 6, 5, 4, 4, 2,
0, -1, -3, -4, -5, -6, -7, -8, -9, -10, -12, -12, -13, -13, -14, -15, -16, -15,
-15, -15, -14, -14, -13, -12, -12, -11, -10, -9, -8, -7, -5, -4, -4, -1, -1, 1,
2, 3, 4, 5, 5, 4, 2, -1, -3, -6, -9, -12, -14, -18, -21, -24, -28, -33, -36,
-40, -45, -49, -54, -58, -62, -64, -68, -70, -71, -72, -71, -70, -67, -64, -60,
-55, -49, -42, -34, -25, -16, -6, };