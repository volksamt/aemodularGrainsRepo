#define DATA_LENGTH 512
#define DATA AKWF_0447

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 13, 22, 30, 37, 43, 49, 55, 60, 64,
69, 73, 76, 79, 83, 85, 88, 90, 92, 94, 95, 97, 99, 100, 102, 103, 104, 105,
107, 107, 108, 109, 110, 111, 111, 112, 112, 114, 113, 114, 114, 114, 115, 116,
116, 116, 117, 116, 117, 117, 118, 118, 117, 117, 118, 118, 118, 119, 118, 119,
119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118, 117, 117, 118, 117, 116,
116, 117, 116, 116, 116, 115, 115, 115, 115, 114, 115, 113, 114, 113, 113, 113,
113, 112, 111, 111, 111, 110, 110, 109, 109, 108, 109, 108, 108, 107, 107, 106,
105, 105, 103, 103, 103, 102, 101, 101, 100, 99, 99, 98, 98, 97, 96, 95, 94, 93,
93, 92, 91, 90, 89, 88, 88, 87, 85, 84, 84, 82, 81, 80, 80, 78, 77, 76, 75, 74,
72, 71, 71, 69, 68, 66, 66, 65, 64, 61, 61, 59, 58, 57, 56, 54, 54, 52, 50, 49,
47, 46, 45, 44, 42, 42, 40, 39, 38, 37, 35, 34, 32, 31, 30, 28, 28, 27, 26, 24,
23, 22, 21, 19, 20, 18, 18, 17, 16, 15, 14, 13, 12, 12, 11, 10, 9, 8, 8, 8, 8,
6, 6, 6, 5, 5, 5, 4, 3, 3, 4, 2, 2, 2, 2, 2, 1, 1, 2, 1, 1, 1, 1, 0, 0, 1, 0, 0,
1, 0, 0, -1, 1, 0, 1, 0, 0, 1, 0, 0, 0, -1, 0, 0, 1, 0, 0, -1, -1, 0, 0, -1, -1,
-1, -2, -3, -2, -2, -2, -3, -4, -3, -4, -4, -4, -5, -5, -6, -7, -8, -8, -8, -9,
-10, -11, -11, -13, -13, -14, -14, -15, -15, -17, -18, -19, -19, -21, -22, -24,
-24, -26, -27, -28, -29, -29, -32, -33, -34, -34, -36, -37, -38, -40, -41, -42,
-43, -44, -45, -47, -49, -50, -52, -52, -54, -55, -56, -58, -59, -60, -62, -63,
-64, -66, -66, -68, -69, -70, -71, -73, -73, -75, -76, -77, -78, -80, -81, -82,
-82, -83, -85, -85, -86, -87, -88, -89, -90, -91, -93, -93, -94, -94, -94, -95,
-97, -97, -98, -98, -99, -100, -100, -101, -102, -103, -103, -104, -104, -105,
-107, -106, -106, -108, -108, -108, -109, -109, -109, -110, -111, -111, -111,
-112, -111, -112, -113, -113, -113, -114, -114, -114, -115, -115, -115, -116,
-116, -116, -116, -116, -117, -117, -117, -118, -117, -117, -118, -118, -118,
-118, -118, -119, -118, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -120, -118, -120, -119, -118, -119,
-118, -118, -118, -118, -118, -118, -117, -117, -117, -117, -116, -117, -116,
-116, -115, -116, -115, -115, -114, -114, -114, -113, -112, -112, -111, -110,
-110, -109, -109, -107, -107, -105, -105, -104, -102, -101, -100, -98, -97, -95,
-93, -91, -89, -87, -83, -81, -77, -73, -70, -65, -60, -55, -48, -41, -33, -24,
-14, -4, };