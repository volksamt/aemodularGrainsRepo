#define DATA_LENGTH 512
#define DATA AKWF_0464

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 39, 53, 60, 64, 66, 67, 69, 76,
84, 92, 101, 106, 109, 107, 99, 89, 76, 63, 50, 38, 31, 24, 18, 13, 7, -1, -8,
-16, -25, -33, -40, -47, -51, -53, -53, -52, -52, -50, -49, -48, -47, -45, -42,
-41, -38, -35, -31, -27, -22, -18, -15, -12, -9, -7, -5, -3, -2, 0, 0, 2, 3, 4,
5, 5, 5, 4, 5, 5, 5, 5, 5, 6, 8, 9, 11, 14, 20, 25, 31, 35, 37, 34, 27, 19, 9,
1, -6, -11, -12, -13, -12, -12, -13, -14, -15, -19, -22, -23, -26, -25, -25,
-22, -19, -14, -10, -7, -4, -2, 0, 1, 2, 4, 5, 7, 8, 11, 13, 15, 17, 17, 17, 15,
15, 13, 13, 13, 12, 11, 10, 10, 9, 7, 6, 4, 4, 2, 1, 0, -1, -2, -3, -4, -3, -4,
-4, -4, -5, -4, -5, -4, -4, -4, -4, -4, -6, -6, -11, -16, -25, -37, -55, -78,
-99, -114, -120, -112, -92, -62, -30, 0, 27, 46, 56, 63, 65, 66, 68, 72, 79, 88,
96, 103, 108, 109, 103, 95, 83, 70, 56, 45, 35, 27, 22, 16, 9, 4, -3, -11, -19,
-28, -36, -43, -47, -51, -53, -52, -52, -51, -49, -48, -47, -45, -44, -43, -40,
-37, -33, -29, -25, -21, -17, -14, -11, -8, -6, -4, -3, -1, 0, 2, 2, 3, 4, 4, 4,
5, 6, 4, 6, 5, 5, 4, 6, 7, 10, 12, 16, 22, 27, 33, 36, 36, 32, 24, 15, 6, -2,
-8, -12, -12, -12, -12, -12, -13, -15, -17, -19, -23, -24, -26, -26, -23, -20,
-17, -12, -8, -6, -3, -1, 0, 1, 2, 3, 6, 8, 10, 12, 14, 16, 17, 17, 15, 16, 15,
14, 13, 12, 11, 11, 10, 10, 8, 6, 6, 4, 3, 1, 1, 0, -2, -2, -3, -3, -3, -4, -4,
-3, -4, -4, -4, -5, -4, -3, -5, -5, -6, -8, -12, -18, -30, -45, -64, -87, -106,
-118, -119, -104, -80, -48, -17, 12, 34, 51, 59, 64, 64, 66, 69, 74, 81, 90, 99,
106, 110, 108, 101, 91, 78, 65, 53, 41, 31, 24, 19, 14, 8, 2, -7, -14, -22, -31,
-39, -45, -49, -52, -53, -53, -51, -51, -49, -48, -46, -46, -43, -41, -38, -35,
-31, -27, -24, -19, -15, -12, -10, -7, -6, -3, -2, -1, 1, 2, 2, 4, 4, 6, 5, 6,
5, 5, 5, 5, 4, 5, 6, 8, 10, 14, 18, 25, 30, 35, 36, 34, 29, 20, 12, 2, -4, -9,
-11, -13, -13, -12, -13, -14, -15, -18, -21, -23, -26, -26, -26, -23, -18, -14,
-11, -7, -5, -2, -1, 1, 2, 3, 5, 7, 9, 11, 14, 15, 15, 16, 16, 16, 16, 14, 13,
13, 12, 11, 10, 10, 9, 7, 6, 5, 4, 3, 1, 0, -1, -2, -3, -3, -3, -3, -3, -3, -4,
-5, -4, -5, -5, -5, -4, -5, -5, -7, -9, -15, -22, -34, -51, -73, -96, -113,
-119, -115, -96, -68, -36, -6, };