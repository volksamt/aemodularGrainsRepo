#define DATA_LENGTH 512
#define DATA AKWF_0418

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 15, 21, 27, 31, 36, 42, 45, 50,
54, 57, 62, 64, 67, 70, 71, 73, 73, 75, 76, 77, 77, 77, 76, 76, 76, 75, 74, 73,
72, 70, 69, 67, 65, 64, 62, 60, 58, 56, 54, 52, 50, 48, 46, 43, 41, 40, 39, 36,
34, 33, 31, 29, 28, 26, 24, 23, 22, 20, 17, 9, 2, -3, -9, -14, -18, -24, -27,
-31, -34, -37, -42, -44, -46, -48, -50, -52, -53, -55, -56, -57, -58, -59, -59,
-59, -60, -59, -59, -59, -59, -57, -57, -57, -55, -55, -54, -53, -53, -52, -51,
-50, -49, -48, -47, -45, -45, -44, -44, -42, -42, -41, -40, -39, -38, -36, -35,
-34, -34, -32, -30, -28, -25, -23, -21, -18, -14, -12, -8, -4, 0, 4, 8, 12, 17,
21, 25, 29, 34, 38, 41, 46, 48, 52, 55, 57, 60, 63, 65, 66, 66, 68, 68, 69, 69,
68, 69, 68, 67, 66, 65, 64, 63, 62, 60, 58, 56, 55, 53, 51, 49, 47, 45, 43, 42,
40, 37, 35, 33, 32, 29, 27, 26, 24, 22, 22, 20, 17, 14, 9, 2, -6, -13, -20, -28,
-35, -41, -48, -55, -60, -66, -72, -77, -82, -86, -91, -95, -98, -102, -106,
-108, -110, -113, -114, -116, -117, -118, -119, -120, -119, -118, -118, -117,
-115, -114, -112, -110, -108, -105, -102, -99, -96, -92, -88, -83, -80, -75,
-71, -65, -61, -55, -50, -44, -40, -34, -29, -24, -18, -13, -8, -3, 3, 8, 13,
17, 22, 26, 30, 34, 38, 42, 47, 49, 53, 56, 59, 61, 65, 67, 69, 71, 73, 74, 76,
76, 78, 78, 79, 80, 78, 79, 79, 79, 77, 77, 76, 75, 73, 72, 70, 67, 66, 63, 61,
58, 55, 54, 50, 47, 45, 42, 38, 35, 32, 29, 26, 23, 21, 18, 17, 15, 13, 12, 11,
10, 9, 10, 10, 10, 11, 12, 13, 15, 16, 18, 19, 21, 22, 25, 26, 27, 29, 30, 31,
32, 33, 33, 35, 35, 34, 34, 33, 34, 34, 32, 32, 30, 30, 28, 28, 27, 25, 24, 23,
21, 19, 19, 18, 16, 15, 14, 13, 12, 9, 8, 7, 7, 6, 5, 4, 2, 2, 2, 1, 2, 1, 0,
-1, 0, -1, 0, 0, 0, 1, 1, 2, 3, 2, 4, 4, 6, 6, 8, 8, 9, 12, 13, 14, 17, 18, 20,
22, 23, 25, 27, 29, 31, 33, 36, 37, 38, 40, 42, 43, 45, 45, 46, 48, 49, 49, 50,
50, 50, 51, 50, 50, 49, 49, 49, 48, 47, 46, 45, 43, 42, 41, 40, 38, 35, 33, 31,
29, 26, 25, 21, 11, 0, -9, -17, -24, -32, -40, -45, -52, -57, -63, -67, -72,
-76, -80, -83, -86, -89, -92, -95, -97, -98, -100, -101, -101, -102, -103, -103,
-103, -103, -103, -103, -101, -101, -100, -99, -98, -97, -96, -94, -93, -91,
-90, -88, -87, -85, -82, -81, -78, -76, -74, -71, -68, -64, -61, -58, -53, -49,
-45, -40, -35, -29, -24, -18, -13, -6, -1, };