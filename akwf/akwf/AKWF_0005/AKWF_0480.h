#define DATA_LENGTH 512
#define DATA AKWF_0480

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 10, 14, 17, 20, 24, 27, 30,
33, 38, 40, 44, 48, 51, 54, 58, 61, 64, 69, 73, 75, 78, 82, 84, 88, 91, 94, 96,
100, 101, 103, 106, 108, 110, 112, 113, 114, 115, 116, 117, 118, 118, 119, 118,
118, 119, 118, 118, 117, 116, 115, 113, 111, 110, 108, 105, 104, 101, 98, 96,
93, 90, 87, 84, 81, 77, 73, 70, 67, 62, 59, 55, 50, 47, 44, 39, 36, 33, 28, 24,
21, 16, 14, 9, 6, 2, 0, -4, -8, -11, -14, -18, -21, -24, -27, -30, -33, -36,
-39, -42, -44, -47, -51, -54, -56, -58, -61, -64, -66, -69, -72, -73, -77, -80,
-81, -84, -86, -88, -91, -93, -95, -96, -99, -100, -102, -104, -106, -106, -109,
-109, -112, -113, -114, -114, -115, -116, -117, -118, -118, -118, -118, -119,
-119, -118, -118, -118, -118, -117, -116, -116, -115, -113, -112, -110, -109,
-107, -105, -103, -101, -98, -96, -94, -92, -88, -85, -82, -80, -76, -74, -70,
-66, -63, -59, -55, -51, -47, -44, -39, -35, -31, -27, -23, -18, -14, -10, -6,
-1, 3, 7, 11, 17, 20, 25, 29, 33, 37, 41, 45, 49, 54, 56, 61, 64, 67, 71, 74,
77, 80, 83, 85, 88, 91, 94, 97, 97, 100, 102, 103, 105, 106, 108, 109, 109, 111,
111, 111, 112, 112, 111, 111, 111, 109, 109, 108, 107, 105, 105, 103, 100, 99,
97, 95, 93, 90, 88, 86, 82, 79, 78, 74, 71, 68, 65, 61, 58, 54, 50, 47, 43, 39,
36, 32, 28, 24, 20, 16, 13, 8, 5, 2, -2, -7, -10, -13, -17, -21, -23, -27, -31,
-34, -37, -39, -43, -47, -48, -51, -54, -57, -59, -62, -63, -64, -68, -70, -71,
-73, -74, -77, -77, -79, -81, -82, -83, -84, -85, -86, -87, -87, -89, -88, -89,
-88, -89, -88, -88, -88, -87, -87, -86, -84, -84, -83, -82, -80, -77, -77, -74,
-72, -71, -68, -66, -64, -60, -58, -55, -53, -49, -46, -43, -40, -36, -34, -30,
-27, -23, -20, -16, -13, -9, -6, -2, 1, 5, 9, 12, 16, 19, 22, 25, 29, 33, 36,
39, 41, 45, 48, 51, 54, 57, 59, 62, 63, 66, 68, 71, 72, 73, 75, 77, 78, 79, 80,
81, 83, 83, 83, 84, 83, 83, 84, 84, 83, 83, 82, 81, 81, 80, 78, 77, 75, 73, 72,
70, 69, 66, 65, 63, 60, 58, 55, 53, 50, 47, 45, 42, 39, 35, 33, 30, 27, 23, 21,
18, 14, 11, 8, 4, 1, -2, -5, -8, -11, -15, -18, -21, -24, -26, -30, -32, -35,
-37, -41, -43, -46, -47, -50, -52, -55, -57, -59, -61, -63, -64, -66, -67, -69,
-70, -71, -72, -73, -73, -75, -75, -76, -75, -76, -77, -76, -76, -77, -76, -76,
-74, -75, -74, -73, -72, -71, -71, -70, -67, -66, -65, -63, -62, -60, -58, -56,
-54, -53, -51, -48, -46, -44, -41, -39, -37, -34, -32, -30, -27, -25, -21, -18,
-16, -13, -11, -7, -4, -2, };