#define DATA_LENGTH 512
#define DATA AKWF_0440

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 4, 6, 4, 4, 4, 5, 6, 4, 3,
1, 1, 2, 5, 8, 10, 11, 13, 14, 15, 17, 18, 20, 21, 22, 24, 26, 28, 30, 31, 31,
33, 35, 37, 38, 40, 41, 42, 44, 45, 47, 49, 49, 51, 52, 53, 54, 56, 58, 59, 60,
61, 63, 64, 64, 67, 67, 69, 70, 71, 72, 73, 75, 75, 76, 79, 78, 80, 81, 82, 82,
84, 86, 86, 87, 88, 88, 90, 91, 91, 92, 93, 94, 95, 95, 96, 97, 97, 99, 100, 99,
101, 101, 102, 102, 103, 104, 104, 104, 105, 105, 106, 107, 106, 107, 107, 109,
108, 109, 108, 109, 110, 110, 110, 111, 111, 111, 111, 111, 110, 111, 112, 112,
112, 112, 112, 112, 112, 111, 112, 111, 111, 111, 111, 111, 111, 111, 109, 110,
109, 109, 109, 109, 109, 107, 107, 107, 106, 106, 105, 105, 105, 105, 104, 103,
103, 102, 102, 101, 100, 100, 99, 97, 97, 96, 96, 94, 94, 94, 92, 92, 91, 89,
90, 89, 88, 86, 85, 85, 83, 83, 81, 81, 80, 78, 78, 76, 75, 74, 73, 71, 71, 69,
68, 67, 66, 64, 63, 62, 60, 60, 58, 57, 55, 55, 52, 52, 51, 49, 47, 45, 44, 43,
41, 39, 38, 38, 36, 35, 34, 31, 30, 29, 27, 26, 25, 23, 22, 19, 18, 16, 15, 14,
12, 11, 9, 7, 5, 2, 0, 1, 3, 4, 5, 6, 3, 3, 3, 5, 5, 3, 2, 1, -1, -3, -3, -4,
-5, -5, -5, -4, -4, -6, -5, -5, -2, 0, -1, -3, -6, -8, -10, -10, -12, -14, -16,
-18, -19, -20, -22, -23, -24, -26, -28, -29, -31, -32, -34, -36, -37, -39, -40,
-41, -43, -44, -45, -47, -49, -49, -51, -52, -54, -54, -57, -58, -59, -60, -62,
-62, -64, -65, -66, -68, -69, -70, -72, -73, -73, -75, -75, -76, -78, -78, -81,
-81, -83, -83, -84, -84, -86, -87, -88, -89, -90, -91, -92, -93, -93, -94, -95,
-96, -96, -97, -97, -98, -99, -100, -101, -101, -102, -102, -104, -103, -104,
-105, -105, -106, -106, -106, -107, -108, -108, -108, -108, -110, -109, -109,
-109, -110, -110, -110, -110, -110, -111, -111, -111, -112, -112, -111, -112,
-112, -112, -112, -111, -112, -111, -110, -112, -110, -111, -111, -111, -111,
-110, -110, -109, -109, -110, -109, -108, -109, -108, -106, -106, -107, -106,
-106, -105, -104, -104, -103, -103, -101, -101, -100, -100, -100, -99, -98, -97,
-97, -96, -95, -95, -93, -92, -91, -91, -90, -89, -89, -87, -86, -85, -84, -83,
-82, -82, -81, -79, -78, -76, -76, -75, -73, -73, -72, -71, -69, -68, -67, -66,
-64, -62, -63, -60, -59, -58, -57, -55, -53, -52, -51, -50, -48, -48, -46, -44,
-44, -41, -40, -39, -38, -36, -35, -33, -32, -30, -29, -27, -25, -24, -22, -21,
-20, -17, -17, -15, -12, -12, -10, -8, -7, -5, -2, 0, 0, -3, -5, -5, -4, -3, -3,
-3, -5, -4, -4, -2, -1, };