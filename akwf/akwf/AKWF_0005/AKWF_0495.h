#define DATA_LENGTH 512
#define DATA AKWF_0495

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2,
2, 2, 2, 2, 2, 1, 2, 2, 1, 2, 1, 2, 1, 2, 2, 1, 2, 2, 1, 2, 1, 2, 1, 1, 2, 1, 1,
1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1,
1, 1, 1, 1, 0, 1, 1, 0, 0, 2, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 4, 9, 6, -5, -6, -2, 1, 2, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1,
0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0,
0, 1, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 1,
1, 0, 0, 1, 0, -1, 0, 0, 0, 0, 1, 0, -1, -2, -3, -19, -63, -103, -89, -43, 0,
15, 12, 7, 4, 6, 7, 8, 6, 6, 7, 7, 6, 6, 5, 6, 6, 6, 6, 6, 5, 5, 5, 5, 5, 5, 6,
4, 5, 5, 5, 5, 4, 5, 5, 4, 5, 4, 5, 4, 4, 4, 4, 4, 4, 3, 4, 3, 3, 4, 3, 4, 4, 3,
3, 3, 3, 3, 4, 3, 3, 4, 3, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 3, 3, 2, 2,
2, 1, 2, 2, 2, 2, 1, 2, 1, 1, 1, 2, 2, 1, 1, 2, 2, 1, 2, 1, 2, 1, 1, 1, 1, 0, 2,
1, 1, 1, 2, 2, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 1, 1, 1, 1, 1, 2, 1, 1, 0, 1, 1,
1, 0, 1, 1, 1, 0, -1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 0, 1, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 0,
0, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 0, 0, 1, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 1, 1,
1, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 0, 1, 0,
1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 1, 1, -1, 0, 0, -1, 1, 1, 0, 0, 1, 1, 0, 1, 0, 1,
0, 1, 1, 0, -1, 0, 0, 0, 0, -1, 1, 0, -1, -3, -14, -57, -116, -111, -47, 7, 17,
8, -1, -1, };