#define DATA_LENGTH 512
#define DATA AKWF_0449

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 26, 32, 35, 38, 39, 41, 44, 47,
50, 52, 55, 58, 60, 61, 63, 64, 65, 65, 66, 66, 67, 67, 67, 68, 67, 67, 68, 69,
68, 68, 68, 69, 68, 68, 68, 68, 69, 68, 69, 69, 69, 68, 69, 69, 68, 68, 69, 69,
68, 68, 68, 69, 68, 68, 69, 68, 68, 69, 69, 68, 68, 68, 68, 69, 68, 68, 68, 68,
68, 68, 69, 69, 69, 69, 68, 68, 68, 69, 68, 69, 68, 68, 68, 68, 69, 68, 69, 69,
68, 68, 68, 68, 68, 69, 69, 69, 68, 69, 68, 68, 68, 69, 68, 68, 68, 69, 68, 68,
68, 69, 68, 69, 68, 68, 68, 68, 69, 68, 68, 68, 67, 68, 68, 68, 68, 68, 68, 69,
69, 68, 68, 68, 68, 68, 68, 69, 68, 68, 68, 68, 67, 68, 68, 69, 68, 69, 67, 68,
68, 68, 68, 67, 69, 68, 68, 68, 68, 68, 68, 67, 68, 68, 67, 67, 68, 68, 67, 67,
68, 68, 69, 68, 68, 68, 68, 68, 68, 68, 67, 68, 68, 68, 69, 67, 67, 68, 68, 68,
68, 69, 69, 68, 68, 67, 68, 68, 67, 68, 68, 67, 67, 68, 68, 68, 68, 68, 67, 68,
68, 68, 68, 67, 67, 69, 67, 70, 87, 97, 104, 108, 108, 106, 102, 101, 101, 102,
103, 105, 105, 107, 108, 108, 108, 109, 110, 110, 109, 109, 109, 109, 108, 109,
108, 109, 108, 108, 109, 109, 109, 109, 109, 109, 102, 56, 6, -24, -44, -53,
-61, -65, -71, -74, -78, -83, -87, -89, -92, -95, -98, -100, -102, -103, -104,
-105, -106, -106, -107, -107, -107, -107, -108, -108, -108, -108, -111, -115,
-116, -118, -119, -119, -114, -102, -90, -80, -79, -80, -83, -84, -85, -86, -86,
-84, -82, -81, -78, -77, -75, -73, -71, -70, -69, -69, -69, -68, -69, -68, -68,
-68, -69, -68, -68, -68, -67, -67, -68, -68, -68, -68, -67, -68, -67, -68, -67,
-68, -67, -68, -67, -68, -68, -67, -67, -67, -67, -68, -67, -67, -68, -68, -67,
-67, -67, -68, -67, -68, -68, -67, -68, -67, -67, -68, -68, -67, -67, -68, -68,
-68, -68, -68, -67, -67, -68, -68, -68, -68, -68, -67, -67, -67, -67, -68, -67,
-67, -68, -67, -67, -67, -67, -67, -67, -68, -68, -67, -67, -67, -67, -68, -68,
-68, -67, -68, -67, -68, -67, -67, -68, -67, -68, -67, -67, -67, -67, -67, -67,
-67, -67, -67, -68, -67, -67, -67, -67, -67, -66, -67, -67, -68, -67, -67, -67,
-66, -67, -68, -66, -67, -68, -67, -67, -67, -67, -67, -66, -66, -67, -67, -67,
-67, -67, -68, -67, -68, -67, -67, -67, -67, -66, -67, -66, -67, -66, -67, -67,
-67, -66, -66, -66, -66, -67, -67, -67, -67, -67, -66, -66, -66, -66, -67, -67,
-67, -66, -66, -67, -67, -67, -66, -67, -67, -67, -67, -67, -66, -67, -67, -67,
-67, -67, -67, -67, -67, -67, -67, -67, -66, -67, -67, -67, -66, -67, -68, -56,
-25, -1, };