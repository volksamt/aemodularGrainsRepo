#define DATA_LENGTH 512
#define DATA AKWF_0427

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 7, 11, 13, 17, 20, 23, 28,
33, 36, 40, 44, 48, 53, 57, 60, 65, 68, 72, 76, 79, 82, 85, 89, 91, 94, 96, 99,
100, 103, 104, 106, 108, 108, 110, 111, 112, 112, 113, 114, 115, 115, 116, 116,
116, 117, 118, 118, 117, 119, 118, 118, 118, 118, 119, 118, 119, 120, 119, 119,
120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118,
118, 118, 119, 119, 119, 120, 120, 119, 120, 118, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 120, 120, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 118, 119,
119, 119, 120, 118, 119, 118, 120, 119, 119, 119, 119, 120, 119, 120, 119, 119,
120, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119,
119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120,
119, 119, 118, 119, 119, 119, 118, 119, 118, 118, 118, 119, 117, 118, 117, 117,
116, 115, 115, 115, 114, 114, 112, 111, 111, 110, 108, 106, 106, 104, 103, 101,
99, 97, 95, 94, 91, 89, 87, 84, 81, 79, 76, 73, 70, 68, 65, 62, 59, 55, 53, 48,
45, 43, 39, 37, 34, 31, 28, 24, 21, 18, 16, 13, 11, 9, 7, 6, 4, 2, 1, 1, 0, -1,
-2, -3, -6, -7, -8, -11, -13, -15, -17, -20, -22, -25, -28, -30, -33, -37, -38,
-41, -44, -46, -50, -53, -55, -58, -59, -63, -65, -67, -70, -72, -74, -76, -78,
-80, -82, -84, -86, -88, -89, -90, -93, -93, -95, -96, -97, -98, -99, -101,
-101, -102, -103, -104, -105, -105, -106, -107, -108, -108, -108, -110, -110,
-110, -111, -111, -111, -112, -112, -113, -113, -113, -114, -113, -113, -114,
-114, -114, -115, -115, -115, -115, -115, -115, -116, -116, -116, -115, -116,
-116, -115, -116, -116, -116, -116, -116, -117, -116, -117, -117, -116, -116,
-116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116,
-116, -117, -116, -116, -115, -115, -115, -115, -115, -115, -115, -114, -115,
-114, -115, -114, -114, -115, -115, -115, -115, -117, -117, -117, -117, -117,
-118, -118, -118, -118, -118, -119, -119, -119, -118, -119, -119, -118, -119,
-120, -119, -119, -119, -118, -119, -118, -118, -118, -118, -117, -116, -116,
-116, -116, -117, -116, -115, -116, -115, -115, -114, -116, -116, -116, -116,
-115, -116, -117, -117, -118, -117, -118, -118, -119, -119, -118, -118, -118,
-120, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -118, -117, -117,
-117, -116, -116, -115, -114, -113, -113, -111, -110, -109, -107, -107, -105,
-102, -101, -98, -96, -94, -91, -89, -86, -84, -80, -77, -73, -71, -66, -63,
-59, -54, -51, -47, -43, -39, -35, -31, -26, -24, -20, -15, -13, -9, -6, -4, -2,
0, 0, };