#define DATA_LENGTH 512
#define DATA AKWF_0425

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 15, 29, 42, 54, 65, 74, 82, 90, 96,
102, 106, 111, 114, 116, 117, 118, 120, 119, 118, 117, 115, 111, 108, 104, 99,
92, 86, 79, 70, 62, 52, 41, 30, 19, 6, -8, -20, -30, -40, -49, -57, -63, -68,
-73, -77, -80, -83, -84, -84, -84, -83, -82, -79, -76, -71, -67, -61, -55, -47,
-39, -31, -21, -11, 1, 12, 21, 30, 40, 49, 56, 62, 67, 72, 75, 79, 81, 83, 84,
84, 83, 81, 80, 77, 73, 68, 62, 56, 47, 40, 29, 19, 6, -6, -18, -30, -43, -53,
-62, -71, -80, -87, -93, -99, -104, -108, -112, -114, -117, -119, -119, -119,
-119, -118, -115, -113, -111, -106, -101, -95, -90, -82, -73, -64, -53, -41,
-29, -14, 1, 16, 30, 43, 54, 64, 74, 83, 90, 97, 101, 107, 110, 114, 115, 117,
119, 119, 118, 118, 117, 114, 111, 108, 103, 99, 93, 86, 78, 70, 62, 51, 41, 30,
18, 4, -8, -20, -31, -40, -49, -56, -63, -69, -73, -77, -80, -82, -83, -85, -84,
-83, -81, -79, -75, -71, -67, -61, -54, -47, -39, -30, -21, -10, 1, 12, 22, 32,
41, 48, 55, 62, 67, 73, 76, 79, 82, 84, 84, 84, 83, 82, 80, 77, 72, 68, 62, 56,
48, 39, 29, 18, 6, -6, -20, -32, -42, -53, -62, -71, -80, -86, -93, -99, -104,
-109, -112, -114, -117, -119, -119, -120, -119, -117, -116, -113, -110, -105,
-102, -96, -88, -82, -73, -63, -53, -41, -27, -14, 1, 17, 30, 44, 55, 65, 75,
83, 91, 97, 102, 106, 111, 114, 117, 118, 118, 119, 119, 118, 116, 114, 110,
106, 103, 98, 92, 85, 78, 70, 60, 51, 40, 29, 17, 4, -9, -21, -31, -41, -49,
-57, -63, -69, -73, -77, -81, -82, -83, -84, -84, -82, -81, -79, -75, -71, -65,
-60, -53, -46, -38, -30, -20, -9, 2, 13, 22, 32, 40, 48, 55, 63, 67, 72, 76, 80,
81, 83, 84, 84, 84, 82, 79, 76, 72, 68, 61, 56, 48, 39, 28, 17, 5, -8, -20, -32,
-44, -54, -64, -72, -80, -87, -93, -99, -105, -108, -112, -115, -117, -118,
-119, -119, -119, -118, -116, -113, -110, -106, -101, -95, -88, -81, -72, -64,
-51, -39, -26, -14, 3, 18, 32, 45, 56, 66, 75, 83, 91, 97, 103, 107, 111, 114,
116, 118, 119, 119, 119, 117, 116, 114, 111, 107, 103, 97, 92, 85, 77, 70, 61,
50, 40, 29, 16, 3, -9, -21, -31, -41, -50, -58, -64, -70, -74, -77, -80, -82,
-84, -84, -84, -82, -80, -78, -75, -71, -66, -59, -54, -46, -38, -30, -19, -9,
1, 14, 22, 32, 41, 50, 56, 63, 68, 72, 76, 80, 82, 83, 85, 84, 83, 82, 79, 77,
72, 67, 62, 54, 47, 38, 28, 17, 5, -8, -21, -33, -44, -54, -64, -73, -81, -87,
-94, -100, -105, -108, -113, -115, -117, -118, -119, -119, -118, -118, -116,
-112, -109, -106, -100, -95, -88, -81, -72, -62, -52, -39, -26, -11, };