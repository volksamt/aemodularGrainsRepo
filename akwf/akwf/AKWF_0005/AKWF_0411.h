#define DATA_LENGTH 512
#define DATA AKWF_0411

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 10, 18, 24, 26, 20, 15, 9, 3, 1,
15, 38, 68, 99, 116, 118, 105, 88, 71, 60, 57, 57, 61, 63, 66, 69, 71, 75, 77,
75, 72, 68, 64, 63, 64, 67, 70, 74, 76, 79, 78, 78, 78, 78, 77, 77, 76, 77, 76,
79, 79, 80, 80, 82, 81, 81, 80, 81, 80, 81, 81, 82, 83, 80, 72, 63, 55, 50, 49,
53, 58, 65, 71, 74, 75, 75, 65, 50, 38, 31, 32, 39, 48, 58, 65, 68, 69, 69, 67,
66, 64, 62, 61, 59, 60, 61, 63, 65, 66, 66, 65, 63, 61, 60, 60, 59, 58, 59, 59,
60, 59, 60, 60, 58, 53, 45, 37, 31, 30, 31, 33, 33, 33, 31, 30, 29, 28, 33, 42,
50, 59, 63, 65, 61, 56, 51, 45, 42, 40, 31, 29, 31, 35, 42, 47, 48, 43, 36, 28,
21, 19, 18, 22, 36, 46, 46, 49, 50, 52, 53, 52, 51, 49, 48, 48, 48, 48, 50, 51,
51, 50, 50, 49, 48, 48, 48, 46, 46, 46, 46, 46, 46, 46, 46, 46, 46, 45, 45, 44,
44, 43, 40, 32, 23, 14, 9, 8, 12, 16, 22, 28, 29, 32, 30, 19, 4, -8, -15, -14,
-7, 2, 11, 17, 21, 22, 18, 7, -1, -6, -10, -9, -8, -6, -4, -2, -1, -3, -4, -8,
-12, -15, -17, -18, -19, -19, -19, -18, -18, -18, -18, -19, -21, -16, -10, -4,
1, 1, 0, -3, -4, -5, -4, -4, -5, -7, -6, 1, 7, 16, 20, 19, 15, 7, -1, -7, -13,
-32, -36, -19, 4, 26, 35, 33, 22, 7, -6, -13, -18, -21, -23, -28, -29, -32, -29,
-27, -27, -27, -31, -37, -40, -44, -44, -44, -43, -42, -42, -43, -43, -43, -44,
-46, -48, -50, -50, -52, -52, -52, -53, -53, -53, -54, -53, -55, -55, -56, -57,
-57, -59, -58, -62, -70, -80, -89, -94, -94, -91, -85, -80, -75, -73, -71, -73,
-84, -100, -111, -118, -117, -110, -100, -91, -84, -81, -80, -82, -82, -84, -85,
-86, -89, -90, -88, -87, -84, -83, -82, -81, -81, -83, -84, -86, -86, -85, -84,
-83, -82, -82, -82, -80, -79, -81, -86, -93, -100, -104, -105, -103, -100, -98,
-99, -99, -100, -99, -97, -92, -83, -72, -64, -59, -58, -60, -64, -69, -73, -76,
-77, -84, -86, -83, -77, -68, -63, -62, -67, -74, -81, -86, -87, -86, -81, -66,
-58, -56, -52, -51, -49, -48, -47, -49, -49, -50, -49, -48, -46, -45, -44, -43,
-43, -44, -43, -44, -44, -44, -44, -43, -43, -43, -42, -42, -42, -42, -41, -42,
-41, -41, -42, -41, -41, -45, -53, -62, -70, -74, -74, -70, -64, -58, -54, -50,
-49, -50, -63, -77, -89, -95, -93, -85, -75, -67, -60, -57, -56, -52, -44, -39,
-38, -40, -43, -46, -48, -47, -43, -40, -37, -36, -35, -34, -35, -34, -34, -34,
-34, -35, -35, -34, -34, -32, -31, -30, -24, -16, -11, -6, -5, -7, -9, -10, -9,
-7, -7, -7, -8, -3, };