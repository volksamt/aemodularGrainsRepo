#define DATA_LENGTH 512
#define DATA AKWF_0445

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 5, 7, 9, 11, 13, 15, 16, 18, 20,
21, 22, 25, 27, 28, 29, 30, 32, 33, 36, 36, 37, 39, 40, 41, 42, 43, 45, 46, 47,
48, 50, 51, 51, 53, 54, 54, 55, 55, 58, 58, 59, 60, 60, 61, 62, 63, 64, 65, 66,
66, 67, 67, 69, 69, 70, 71, 72, 71, 72, 74, 74, 75, 74, 76, 76, 77, 77, 78, 78,
79, 79, 80, 81, 81, 82, 82, 83, 84, 84, 84, 84, 85, 85, 87, 86, 87, 88, 88, 88,
88, 90, 90, 89, 90, 91, 91, 92, 92, 92, 92, 93, 93, 94, 94, 94, 95, 95, 95, 95,
96, 96, 97, 97, 97, 98, 97, 98, 98, 98, 99, 99, 100, 100, 100, 100, 101, 101,
101, 101, 101, 102, 102, 103, 102, 103, 103, 103, 104, 104, 103, 105, 104, 105,
105, 105, 105, 106, 105, 106, 107, 106, 107, 106, 107, 107, 107, 108, 108, 108,
109, 109, 108, 108, 109, 109, 109, 109, 109, 109, 110, 110, 109, 110, 111, 111,
111, 110, 111, 111, 111, 112, 112, 112, 113, 111, 112, 112, 113, 113, 112, 114,
113, 113, 113, 113, 114, 113, 114, 114, 113, 115, 114, 115, 115, 115, 115, 116,
115, 116, 115, 115, 115, 116, 116, 116, 115, 117, 117, 116, 116, 116, 117, 117,
117, 117, 117, 117, 117, 117, 118, 118, 117, 117, 118, 118, 118, 119, 118, 118,
119, 118, 119, 118, 119, 118, 119, 117, 120, 104, 44, -4, -34, -52, -63, -71,
-76, -82, -84, -89, -94, -98, -100, -104, -106, -109, -110, -112, -112, -114,
-114, -115, -115, -115, -115, -116, -116, -116, -117, -115, -116, -116, -117,
-117, -116, -115, -116, -116, -117, -116, -116, -116, -115, -115, -116, -116,
-115, -114, -115, -115, -115, -115, -115, -115, -115, -114, -114, -114, -114,
-114, -114, -113, -114, -113, -114, -113, -113, -113, -113, -112, -112, -112,
-112, -112, -111, -112, -112, -112, -111, -111, -111, -111, -110, -111, -110,
-110, -110, -110, -110, -110, -109, -108, -109, -108, -108, -108, -108, -109,
-109, -108, -107, -108, -106, -108, -108, -107, -107, -106, -106, -105, -106,
-106, -105, -105, -104, -104, -105, -105, -104, -103, -104, -103, -104, -104,
-102, -102, -102, -102, -101, -101, -102, -102, -101, -101, -100, -100, -99,
-99, -100, -98, -99, -98, -97, -98, -97, -96, -96, -97, -96, -95, -95, -95, -95,
-94, -95, -94, -93, -93, -93, -93, -92, -91, -92, -91, -91, -91, -90, -89, -89,
-88, -88, -88, -87, -86, -87, -86, -85, -84, -84, -84, -83, -83, -83, -82, -81,
-81, -80, -80, -80, -78, -79, -78, -77, -77, -76, -76, -75, -74, -74, -73, -72,
-72, -71, -70, -70, -69, -68, -68, -67, -66, -65, -65, -64, -63, -62, -62, -60,
-59, -59, -58, -56, -56, -55, -54, -52, -51, -51, -49, -48, -48, -46, -45, -45,
-43, -41, -41, -39, -38, -37, -35, -35, -33, -32, -29, -28, -27, -26, -24, -22,
-21, -19, -17, -15, -14, -11, -9, -8, -6, -4, -2, 0, };