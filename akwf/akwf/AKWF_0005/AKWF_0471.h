#define DATA_LENGTH 512
#define DATA AKWF_0471

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 18, 17, 17, 17, 17, 16, 17, 17,
17, 17, 17, 17, 18, 18, 18, 17, 17, 16, 18, 18, 17, 17, 17, 17, 17, 18, 16, 17,
17, 17, 17, 17, 16, 18, 17, 17, 17, 17, 17, 17, 18, 17, 18, 17, 17, 17, 17, 18,
17, 17, 17, 17, 17, 17, 17, 17, 18, 17, 17, 16, 17, 16, 18, 17, 17, 17, 18, 16,
18, 17, 17, 16, 17, 16, 18, 17, 18, 16, 18, 16, 19, 51, 52, 51, 52, 51, 52, 50,
51, 50, 52, 51, 51, 51, 51, 51, 51, 51, 51, 51, 51, 51, 52, 51, 51, 50, 51, 51,
51, 52, 51, 50, 51, 51, 52, 51, 51, 51, 50, 52, 51, 50, 51, 51, 52, 52, 52, 51,
52, 51, 51, 51, 51, 51, 51, 51, 51, 51, 51, 51, 51, 52, 52, 51, 51, 51, 51, 53,
49, 78, 88, 83, 87, 84, 86, 84, 85, 84, 85, 85, 85, 85, 85, 84, 85, 85, 85, 85,
85, 84, 85, 85, 85, 85, 85, 85, 84, 84, 84, 85, 85, 85, 84, 85, 84, 85, 85, 85,
85, 86, 84, 86, 84, 86, 85, 85, 84, 86, 83, 85, 84, 86, 84, 86, 85, 85, 85, 86,
85, 84, 87, 83, 88, 79, 93, 72, 109, -32, -128, -105, -128, -113, -124, -116,
-122, -117, -121, -118, -119, -119, -119, -120, -119, -120, -118, -120, -118,
-120, -118, -119, -119, -120, -119, -119, -119, -120, -118, -120, -119, -119,
-119, -120, -118, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119,
-118, -119, -119, -119, -120, -119, -120, -118, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -120, -117, -123, -95, -82, -87, -83,
-86, -85, -85, -85, -86, -84, -85, -85, -85, -85, -86, -85, -85, -84, -85, -86,
-85, -84, -85, -85, -84, -85, -85, -85, -85, -86, -85, -85, -85, -85, -85, -85,
-85, -84, -84, -85, -85, -85, -86, -85, -85, -85, -85, -85, -85, -85, -85, -85,
-85, -85, -85, -85, -85, -85, -85, -85, -84, -86, -85, -86, -84, -86, -82, -89,
-70, -47, -53, -51, -52, -51, -52, -51, -52, -52, -51, -51, -51, -51, -51, -51,
-50, -51, -51, -51, -52, -51, -51, -51, -50, -51, -51, -51, -51, -51, -51, -51,
-51, -51, -52, -51, -51, -50, -52, -52, -50, -52, -52, -51, -51, -52, -51, -52,
-52, -50, -51, -51, -51, -51, -51, -51, -50, -51, -50, -52, -51, -52, -50, -52,
-50, -52, -50, -54, -45, -15, -18, -16, -17, -16, -18, -17, -17, -18, -17, -17,
-17, -17, -17, -17, -17, -18, -17, -18, -18, -17, -17, -18, -17, -17, -18, -17,
-17, -17, -17, -18, -17, -16, -17, -17, -17, -18, -17, -18, -16, -17, -17, -18,
-17, -18, -16, -17, -16, -18, -17, -17, -17, -18, -17, -17, -17, -17, -17, -17,
-16, -18, -17, -18, -17, -17, -17, -17, -17, -17, -17, -17, -18, -17, -18, -15,
};