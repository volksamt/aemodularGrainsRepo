#define DATA_LENGTH 512
#define DATA AKWF_0490

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 11, 7, 4, 5, 9, 12, 16, 18, 20, 22,
22, 21, 22, 25, 35, 46, 56, 65, 73, 80, 86, 91, 96, 101, 105, 109, 111, 114,
115, 116, 118, 119, 119, 119, 118, 117, 115, 112, 108, 105, 98, 68, 22, 12, 39,
53, 51, 48, 36, 14, -4, -17, -33, -56, -81, -98, -106, -108, -111, -116, -117,
-112, -101, -93, -89, -88, -89, -89, -90, -89, -90, -89, -90, -91, -91, -93,
-96, -101, -108, -116, -119, -116, -109, -96, -78, -55, -31, -16, -11, -5, -1,
7, 14, 21, 28, 43, 66, 89, 103, 111, 115, 118, 119, 120, 118, 115, 114, 112,
111, 111, 112, 113, 114, 117, 119, 119, 119, 116, 115, 110, 104, 95, 83, 68, 49,
32, 19, 16, 17, 13, 8, 3, 1, -5, -7, -8, -11, -14, -18, -21, -22, -23, -23, -22,
-22, -23, -23, -22, -22, -22, -20, -18, -16, -13, -10, -7, -5, -5, -4, 2, 7, 7,
7, 9, 14, 16, 19, 21, 23, 22, 21, 19, 19, 19, 19, 20, 20, 19, 19, 19, 21, 22,
23, 22, 18, 16, 11, 8, 5, 4, 3, -2, -7, -8, -9, -14, -17, -22, -22, -23, -24,
-32, -45, -57, -66, -74, -79, -84, -87, -90, -93, -93, -94, -95, -94, -93, -91,
-88, -85, -80, -76, -70, -62, -54, -44, -35, -25, -20, -19, -21, -21, -18, -16,
-10, -7, -4, -4, -7, -6, 3, 9, 10, 5, 2, 4, 6, 8, 9, 10, 9, 9, 9, 8, 9, 8, 6, 6,
5, 4, 3, 6, 10, 9, 3, -6, -12, -9, -4, -3, -5, -8, -9, -11, -13, -14, -15, -16,
-17, -18, -19, -18, -19, -18, -18, -17, -17, -16, -15, -14, -12, -11, -9, -7,
-5, -4, -4, -7, -8, -3, 6, 11, 7, 3, 4, 7, 11, 14, 15, 17, 19, 21, 22, 22, 22,
23, 22, 23, 21, 21, 19, 19, 20, 19, 21, 21, 22, 23, 23, 23, 23, 21, 21, 20, 19,
18, 17, 15, 14, 13, 10, 9, 7, 6, 5, 4, 4, 3, 3, 3, 6, 7, 10, 13, 14, 14, 13, 13,
11, 9, 6, 3, 3, 2, 3, 3, 4, 5, 6, 7, 8, 9, 10, 12, 13, 14, 15, 16, 17, 17, 18,
19, 19, 20, 20, 20, 20, 20, 20, 20, 19, 19, 18, 18, 18, 17, 16, 15, 14, 13, 11,
10, 7, 6, 5, 3, 3, 4, 8, 11, 7, -2, -10, -13, -10, -5, -2, -3, -5, -6, -8, -8,
-10, -11, -11, -12, -13, -14, -14, -15, -16, -15, -15, -16, -16, -15, -17, -16,
-16, -17, -16, -16, -15, -15, -16, -16, -15, -15, -15, -15, -14, -15, -14, -14,
-15, -15, -16, -16, -15, -16, -15, -17, -16, -17, -17, -18, -18, -19, -19, -19,
-19, -21, -22, -22, -22, -23, -23, -23, -23, -23, -24, -22, -23, -22, -22, -22,
-23, -23, -22, -23, -22, -22, -22, -22, -22, -21, -21, -20, -19, -17, -15, -14,
-13, -11, -8, -6, -5, -3, -5, -8, -7, -2, };