#define DATA_LENGTH 512
#define DATA AKWF_0428

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 60, 76, 85, 88, 85, 79, 71, 61,
53, 47, 43, 44, 48, 57, 77, 113, 121, 118, 119, 111, 112, 113, 106, 93, 82, 75,
75, 82, 91, 102, 108, 109, 102, 93, 84, 78, 76, 84, 100, 110, 101, 65, 24, -4,
-22, -49, -88, -104, -79, -60, -57, -38, 1, 35, 51, 56, 54, 47, 39, 31, 23, 18,
17, 17, 18, 20, 18, 15, 11, 5, -1, -6, -7, -5, -6, -8, -9, -12, -15, -16, -19,
-21, -22, -23, -24, -25, -26, -27, -27, -27, -28, -28, -28, -29, -29, -30, -30,
-30, -29, -30, -29, -30, -29, -29, -30, -29, -29, -28, -28, -28, -28, -28, -28,
-28, -27, -27, -28, -30, -33, -35, -35, -33, -31, -29, -25, -23, -23, -22, -22,
-24, -28, -34, -43, -58, -77, -100, -116, -120, -113, -97, -83, -76, -81, -95,
-101, -89, -62, -31, -6, 6, 13, 17, 21, 21, 26, 39, 57, 77, 90, 90, 78, 58, 40,
25, 20, 21, 28, 37, 45, 47, 41, 26, 4, -17, -32, -41, -44, -42, -38, -32, -25,
-19, -14, -10, -8, -5, -3, -1, 0, 2, 4, 4, 6, 6, 5, 4, 2, 1, 0, -1, -1, -1, -2,
-2, -2, -1, -1, -2, 0, -1, -1, -1, -1, -1, -1, -1, -2, -1, -1, -1, 0, 0, 0, 1,
1, 0, 1, 1, 1, 1, 1, 1, 2, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0,
0, 1, 0, 0, -1, 0, 0, 0, 0, 2, 4, 4, 3, 0, -5, -8, -10, -9, -4, 12, 43, 77, 96,
87, 71, 58, 48, 42, 38, 37, 37, 37, 41, 55, 68, 48, 1, -36, -53, -66, -75, -80,
-83, -75, -61, -43, -25, -13, -3, 1, 3, 7, 15, 27, 54, 92, 105, 82, 70, 73, 60,
31, 6, -7, -6, 4, 18, 25, 19, 3, -15, -31, -38, -39, -34, -27, -20, -12, -7, -4,
-1, -2, -4, -7, -8, -9, -9, -8, -7, -6, -7, -8, -8, -10, -12, -13, -15, -17,
-18, -19, -20, -20, -21, -21, -22, -22, -22, -22, -21, -19, -17, -15, -11, -5,
2, 13, 25, 39, 53, 64, 68, 63, 54, 41, 29, 20, 17, 21, 33, 47, 54, 52, 37, 12,
-14, -36, -51, -57, -56, -56, -57, -56, -56, -60, -72, -88, -107, -119, -120,
-119, -117, -98, -80, -65, -57, -58, -63, -70, -78, -85, -89, -88, -82, -72,
-57, -44, -31, -20, -13, -9, -7, -9, -9, -11, -13, -13, -15, -15, -15, -16, -17,
-16, -16, -16, -17, -17, -17, -17, -16, -16, -16, -14, -14, -13, -13, -11, -10,
-10, -9, -9, -7, -7, -6, -5, -4, -3, -2, 0, 0, 1, 2, 3, 4, 4, 5, 6, 6, 8, 8, 9,
9, 11, 12, 13, 13, 14, 14, 15, 16, 18, 19, 19, 20, 21, 22, 23, 23, 25, 25, 26,
28, 29, 31, 31, 33, 34, 34, 34, 32, 28, 19, 2, -26, -52, -63, -50, -36, -39,
-43, -17, };