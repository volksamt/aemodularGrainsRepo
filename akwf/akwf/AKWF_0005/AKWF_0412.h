#define DATA_LENGTH 512
#define DATA AKWF_0412

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 1,
1, 1, 1, 1, 0, 1, 0, 2, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1,
1, 2, 5, 20, 49, 86, 110, 118, 117, 109, 97, 85, 73, 63, 54, 46, 38, 27, 12, -4,
-17, -31, -41, -47, -52, -54, -56, -56, -57, -59, -59, -61, -61, -62, -61, -62,
-62, -62, -61, -61, -62, -61, -61, -60, -59, -59, -58, -57, -57, -56, -55, -54,
-53, -51, -50, -49, -48, -46, -44, -42, -39, -35, -31, -27, -23, -19, -17, -15,
-11, -9, -4, -1, 3, 7, 10, 13, 15, 17, 18, 19, 20, 22, 23, 25, 26, 28, 28, 29,
31, 31, 32, 32, 33, 34, 34, 34, 34, 34, 34, 33, 33, 33, 33, 32, 31, 31, 31, 30,
29, 28, 27, 26, 25, 24, 24, 23, 22, 21, 21, 20, 19, 18, 19, 17, 17, 16, 15, 14,
14, 14, 16, 29, 55, 82, 100, 106, 101, 89, 75, 63, 55, 49, 44, 37, 29, 17, 5,
-6, -17, -26, -34, -40, -45, -47, -51, -51, -52, -53, -54, -56, -55, -55, -55,
-56, -55, -56, -55, -56, -56, -56, -55, -55, -54, -54, -54, -52, -51, -51, -50,
-48, -47, -46, -44, -43, -41, -39, -36, -33, -30, -26, -23, -21, -18, -17, -15,
-13, -11, -8, -4, -2, 0, 4, 7, 9, 11, 12, 13, 15, 17, 17, 17, 19, 19, 20, 21,
22, 21, 23, 23, 23, 24, 24, 23, 24, 24, 24, 24, 24, 23, 23, 23, 23, 22, 22, 22,
22, 21, 20, 20, 20, 19, 19, 18, 18, 17, 17, 17, 16, 16, 16, 14, 14, 14, 13, 13,
12, 12, 12, 15, 30, 59, 90, 112, 120, 115, 108, 98, 86, 72, 62, 53, 46, 36, 25,
11, -6, -19, -33, -42, -49, -53, -55, -56, -57, -57, -59, -60, -61, -62, -62,
-63, -63, -63, -63, -63, -63, -62, -62, -61, -61, -60, -60, -59, -58, -57, -57,
-56, -56, -53, -53, -51, -50, -49, -47, -46, -43, -39, -37, -32, -28, -25, -20,
-18, -16, -12, -9, -6, -2, 2, 5, 9, 12, 14, 16, 18, 18, 20, 22, 23, 25, 25, 27,
28, 30, 30, 32, 33, 33, 34, 34, 34, 35, 35, 35, 34, 34, 34, 34, 33, 33, 32, 32,
31, 31, 29, 28, 28, 27, 26, 25, 24, 24, 23, 22, 21, 21, 19, 19, 18, 17, 17, 17,
15, 14, 15, 14, 12, 12, 11, 10, 10, 8, 8, 6, 6, 5, 4, 3, 2, 2, 1, 1, -1, -1, -1,
-2, -2, -3, -2, -3, -4, -4, -4, -5, -5, -5, -5, -6, -7, -6, -7, -7, -6, -7, -7,
-7, -6, -6, -7, -7, -6, -7, -6, -6, -6, -6, -6, -5, -6, -5, -4, -5, -4, -4, -5,
-4, -3, -4, -4, -3, -3, -3, -2, -3, -3, -2, -1, -2, -1, -1, -1, -2, 0, -1, -1,
-1, -1, 0, 0, 0, 1, 0, };