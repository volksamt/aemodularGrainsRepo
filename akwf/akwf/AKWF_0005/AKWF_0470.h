#define DATA_LENGTH 512
#define DATA AKWF_0470

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 12, 18, 24, 28, 34, 38, 43, 46,
51, 56, 60, 64, 68, 72, 75, 79, 83, 86, 89, 90, 93, 96, 98, 100, 103, 104, 105,
106, 108, 109, 109, 110, 111, 111, 111, 113, 112, 112, 112, 112, 113, 111, 112,
112, 111, 112, 111, 111, 111, 111, 111, 110, 110, 109, 110, 110, 109, 110, 110,
110, 110, 110, 110, 110, 111, 111, 112, 112, 112, 112, 111, 111, 112, 110, 110,
110, 110, 111, 110, 109, 109, 108, 108, 107, 106, 105, 105, 103, 102, 101, 100,
99, 99, 97, 95, 94, 93, 92, 91, 89, 88, 87, 85, 84, 83, 82, 80, 78, 77, 76, 74,
73, 72, 70, 69, 68, 66, 65, 63, 62, 60, 58, 58, 56, 53, 52, 51, 49, 47, 46, 45,
43, 41, 39, 38, 37, 36, 33, 32, 30, 28, 27, 26, 23, 22, 21, 19, 17, 16, 15, 13,
11, 11, 9, 8, 6, 6, 4, 3, 3, 1, 0, -1, -1, -2, -4, -4, -4, -5, -6, -5, -6, -7,
-7, -7, -7, -6, -8, -6, -6, -6, -5, -5, -3, -2, -2, 0, 0, 1, 4, 6, 7, 10, 11,
13, 17, 20, 23, 25, 27, 30, 33, 35, 39, 41, 44, 48, 50, 54, 57, 60, 64, 67, 70,
73, 76, 80, 82, 85, 88, 91, 93, 96, 97, 100, 101, 102, 103, 104, 105, 104, 104,
104, 102, 102, 101, 99, 99, 97, 95, 94, 92, 90, 88, 86, 85, 82, 81, 78, 76, 74,
71, 70, 66, 65, 62, 59, 56, 54, 50, 48, 45, 42, 40, 37, 34, 31, 28, 24, 21, 17,
12, 10, 5, 1, -2, -7, -12, -15, -20, -23, -26, -29, -32, -35, -38, -41, -43,
-46, -48, -50, -53, -54, -57, -58, -61, -63, -65, -65, -68, -70, -70, -72, -74,
-74, -75, -77, -78, -80, -81, -81, -82, -82, -83, -85, -86, -85, -86, -87, -87,
-88, -89, -91, -92, -93, -94, -96, -97, -97, -99, -99, -101, -102, -104, -105,
-107, -106, -108, -109, -111, -112, -113, -113, -114, -115, -115, -117, -117,
-118, -118, -118, -119, -119, -119, -118, -119, -118, -117, -118, -117, -115,
-114, -113, -112, -111, -110, -108, -108, -106, -104, -102, -101, -99, -98, -96,
-94, -92, -91, -90, -88, -87, -84, -83, -81, -80, -78, -77, -74, -73, -71, -69,
-67, -66, -65, -63, -61, -60, -57, -56, -55, -53, -52, -50, -48, -47, -45, -43,
-42, -40, -38, -36, -34, -33, -31, -30, -28, -27, -25, -24, -23, -21, -21, -19,
-18, -18, -16, -16, -15, -14, -15, -15, -15, -15, -15, -16, -17, -19, -19, -21,
-23, -24, -26, -28, -30, -32, -34, -37, -38, -41, -44, -47, -51, -53, -57, -60,
-63, -67, -70, -73, -77, -80, -84, -87, -90, -93, -94, -97, -100, -102, -103,
-105, -106, -106, -107, -107, -106, -106, -104, -103, -101, -99, -98, -95, -93,
-91, -88, -87, -83, -81, -77, -75, -73, -69, -67, -63, -61, -57, -53, -50, -47,
-44, -40, -37, -33, -29, -25, -20, -14, -9, -3, };