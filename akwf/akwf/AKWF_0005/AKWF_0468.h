#define DATA_LENGTH 512
#define DATA AKWF_0468

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 17, 22, 27, 33, 39, 46, 55,
62, 71, 78, 85, 91, 96, 100, 103, 104, 105, 105, 105, 102, 100, 97, 93, 88, 83,
77, 71, 65, 58, 53, 46, 39, 35, 29, 24, 19, 14, 11, 6, 2, 0, -4, -6, -7, -9,
-11, -12, -13, -13, -14, -13, -14, -15, -14, -14, -14, -15, -14, -14, -13, -13,
-12, -12, -11, -11, -11, -10, -10, -9, -9, -9, -8, -8, -7, -7, -6, -5, -4, -4,
-2, -2, -1, 0, 1, 2, 3, 4, 3, 1, 0, -4, -8, -12, -15, -18, -21, -24, -25, -26,
-26, -27, -26, -25, -24, -23, -20, -17, -14, -11, -6, -3, 2, 5, 8, 9, 10, 9, 8,
4, 2, -1, -4, -5, -7, -9, -10, -11, -10, -11, -11, -10, -10, -8, -7, -5, -3, 1,
3, 5, 8, 12, 15, 19, 23, 29, 36, 42, 48, 54, 60, 64, 68, 72, 73, 74, 74, 74, 72,
70, 67, 64, 59, 55, 50, 44, 38, 32, 26, 21, 15, 11, 7, 6, 6, 6, 7, 9, 9, 11, 12,
11, 12, 12, 11, 10, 9, 8, 8, 5, 3, 0, -3, -7, -10, -14, -18, -21, -24, -26, -29,
-28, -27, -24, -22, -18, -15, -12, -10, -8, -6, -6, -4, -4, -4, -3, -3, -4, -5,
-6, -8, -10, -12, -15, -17, -18, -19, -18, -14, -8, 0, 9, 18, 27, 34, 40, 46,
50, 52, 54, 56, 56, 55, 53, 49, 46, 42, 36, 29, 22, 14, 6, -1, -9, -17, -25,
-32, -38, -45, -49, -53, -57, -59, -61, -60, -60, -60, -61, -62, -62, -63, -64,
-64, -64, -64, -64, -64, -63, -63, -61, -60, -60, -60, -58, -57, -56, -56, -54,
-53, -52, -51, -51, -54, -58, -66, -74, -82, -91, -99, -105, -111, -114, -118,
-119, -119, -118, -116, -114, -109, -103, -97, -90, -82, -73, -63, -53, -44,
-34, -25, -17, -10, -6, -2, 0, 2, 2, 2, 2, 3, 3, 2, 2, 3, 3, 3, 2, 3, 3, 4, 4,
6, 8, 9, 11, 13, 14, 16, 17, 16, 15, 12, 9, 4, 0, -4, -9, -12, -16, -18, -21,
-23, -24, -25, -26, -27, -27, -26, -25, -24, -22, -21, -18, -15, -14, -11, -12,
-12, -14, -17, -21, -24, -28, -31, -32, -35, -36, -37, -38, -38, -37, -37, -35,
-34, -32, -29, -26, -22, -19, -14, -10, -6, -2, 3, 9, 15, 21, 29, 37, 45, 53,
60, 66, 71, 75, 79, 81, 82, 83, 83, 83, 81, 80, 76, 72, 69, 64, 59, 54, 50, 44,
39, 35, 32, 32, 32, 32, 34, 35, 37, 39, 39, 40, 41, 41, 40, 39, 39, 38, 37, 34,
32, 29, 26, 22, 19, 15, 11, 7, 4, 0, -3, -6, -9, -12, -15, -16, -18, -20, -21,
-23, -23, -24, -25, -23, -23, -22, -22, -21, -19, -17, -16, -14, -13, -11, -7,
-7, -4, -3, -2, -2, -4, -7, -10, -13, -16, -19, -20, -22, -23, -23, -23, -24,
-21, -19, -17, -15, -12, -9, -5, -1, };