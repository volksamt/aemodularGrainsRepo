#define DATA_LENGTH 512
#define DATA AKWF_0455

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 0, 0, 0, 1, 1, 0, 1, 0, 1, 0,
0, 1, 3, 7, 13, 17, 22, 27, 31, 35, 39, 43, 46, 50, 54, 56, 61, 63, 66, 68, 71,
74, 77, 77, 80, 82, 83, 86, 87, 90, 90, 92, 94, 95, 95, 97, 97, 100, 99, 100,
102, 102, 103, 104, 104, 105, 105, 107, 107, 108, 108, 108, 109, 110, 111, 110,
112, 112, 111, 112, 112, 113, 113, 113, 113, 114, 114, 114, 114, 116, 115, 115,
116, 116, 117, 117, 116, 117, 117, 118, 118, 117, 117, 117, 118, 117, 119, 118,
119, 118, 118, 118, 119, 118, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 120, 118, 119, 119,
119, 119, 118, 118, 118, 119, 118, 119, 117, 118, 118, 117, 118, 118, 117, 118,
116, 117, 117, 117, 116, 116, 117, 116, 115, 115, 115, 114, 114, 113, 114, 114,
113, 113, 112, 112, 112, 112, 111, 111, 111, 110, 110, 109, 109, 108, 107, 107,
106, 105, 105, 104, 104, 103, 102, 101, 101, 99, 98, 97, 96, 95, 94, 93, 91, 90,
89, 86, 86, 84, 82, 79, 77, 74, 72, 69, 67, 64, 61, 57, 53, 48, 44, 38, 32, 27,
24, 22, 19, 18, 16, 15, 13, 11, 10, 7, 7, 5, 4, 4, 2, 2, 3, 1, 1, 2, 1, 2, 3, 8,
9, 4, -3, -7, -7, -3, -1, 1, 0, 1, 0, 1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0,
0, 0, 0, -1, -4, -8, -12, -17, -23, -28, -32, -35, -40, -43, -47, -50, -54, -57,
-61, -64, -66, -68, -71, -74, -76, -78, -80, -82, -84, -86, -87, -89, -91, -91,
-94, -94, -95, -96, -98, -98, -100, -101, -101, -103, -103, -104, -104, -106,
-105, -106, -108, -108, -109, -109, -109, -110, -111, -111, -111, -112, -112,
-112, -113, -113, -113, -113, -114, -114, -115, -115, -116, -116, -116, -116,
-116, -116, -116, -117, -116, -117, -117, -117, -118, -117, -118, -118, -117,
-119, -117, -118, -118, -119, -118, -118, -118, -118, -119, -119, -119, -118,
-119, -120, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119, -119,
-118, -119, -120, -120, -119, -119, -119, -119, -119, -119, -118, -118, -119,
-119, -118, -119, -117, -117, -117, -118, -118, -117, -118, -117, -117, -116,
-117, -116, -116, -116, -116, -115, -116, -116, -115, -115, -114, -114, -114,
-114, -114, -113, -113, -113, -113, -112, -111, -111, -110, -110, -111, -110,
-110, -109, -108, -107, -106, -106, -106, -105, -104, -104, -103, -102, -100,
-99, -99, -98, -98, -96, -95, -93, -92, -91, -89, -88, -86, -85, -83, -81, -79,
-76, -74, -71, -69, -66, -64, -59, -56, -52, -48, -43, -37, -32, -27, -23, -21,
-20, -19, -16, -15, -13, -11, -10, -8, -7, -5, -4, -4, -3, -3, -2, -1, -1, -1,
-2, -1, -4, -8, -9, -3, 4, 7, 6, 3, 1, 0, -1, -2, 0, 0, 0, };