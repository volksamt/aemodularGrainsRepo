#define DATA_LENGTH 512
#define DATA AKWF_0408

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 4, 6, 8, 10, 12, 13, 14, 16, 17,
18, 18, 19, 21, 21, 21, 21, 21, 21, 21, 21, 20, 20, 19, 18, 18, 17, 18, 17, 15,
14, 14, 13, 12, 13, 12, 10, 10, 10, 10, 10, 9, 9, 9, 9, 9, 9, 9, 9, 9, 10, 11,
10, 10, 11, 11, 13, 13, 14, 13, 14, 15, 15, 16, 17, 17, 19, 19, 19, 20, 20, 21,
21, 23, 23, 23, 24, 24, 25, 26, 26, 26, 28, 27, 28, 28, 30, 29, 30, 30, 30, 31,
31, 32, 32, 32, 33, 32, 32, 32, 33, 33, 33, 33, 33, 34, 33, 33, 33, 32, 32, 32,
32, 32, 32, 31, 30, 31, 30, 29, 29, 29, 28, 28, 27, 26, 27, 27, 26, 26, 26, 26,
26, 26, 26, 26, 26, 26, 26, 27, 27, 27, 28, 28, 28, 29, 29, 30, 31, 31, 32, 32,
33, 34, 34, 34, 35, 36, 37, 37, 37, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38,
38, 38, 37, 37, 38, 37, 37, 36, 35, 35, 34, 34, 34, 34, 33, 33, 33, 33, 32, 32,
31, 31, 31, 31, 30, 31, 30, 31, 30, 30, 30, 30, 30, 30, 29, 30, 30, 30, 30, 30,
30, 30, 30, 30, 30, 31, 31, 31, 31, 31, 31, 31, 31, 32, 32, 32, 32, 31, 32, 31,
31, 32, 32, 32, 31, 32, 32, 31, 31, 31, 32, 31, 31, 30, 31, 30, 31, 31, 31, 31,
31, 30, 30, 30, 30, 29, 30, 29, 30, 29, 29, 28, 28, 27, 27, 27, 27, 27, 26, 26,
25, 26, 26, 25, 24, 25, 24, 24, 24, 23, 24, 23, 23, 23, 23, 23, 22, 23, 22, 22,
22, 22, 22, 22, 22, 22, 22, 22, 21, 21, 22, 22, 23, 22, 22, 22, 22, 22, 23, 23,
22, 23, 20, 13, 7, 2, -5, -11, -19, -25, -33, -39, -46, -54, -60, -66, -73, -80,
-86, -91, -96, -101, -105, -108, -112, -114, -117, -117, -118, -119, -119, -118,
-117, -115, -113, -111, -107, -103, -100, -96, -92, -86, -83, -77, -73, -68,
-63, -59, -54, -50, -45, -42, -38, -35, -33, -30, -28, -26, -24, -23, -22, -22,
-21, -22, -23, -25, -25, -27, -28, -30, -31, -35, -37, -39, -41, -43, -46, -47,
-51, -52, -55, -56, -58, -59, -61, -62, -62, -64, -65, -65, -66, -66, -66, -65,
-65, -65, -65, -64, -64, -63, -61, -60, -60, -59, -58, -56, -55, -54, -53, -52,
-50, -50, -49, -47, -46, -45, -44, -43, -41, -40, -40, -38, -37, -36, -35, -33,
-32, -30, -29, -28, -26, -24, -23, -22, -20, -19, -17, -16, -14, -13, -13, -11,
-9, -8, -7, -7, -6, -5, -4, -3, -5, -4, -4, -3, -4, -5, -5, -6, -7, -7, -9, -10,
-10, -12, -13, -14, -15, -17, -18, -19, -19, -21, -22, -23, -24, -25, -25, -25,
-25, -25, -25, -25, -25, -24, -23, -23, -21, -20, -18, -18, -16, -14, -13, -11,
-9, -7, -4, -3, -1, };