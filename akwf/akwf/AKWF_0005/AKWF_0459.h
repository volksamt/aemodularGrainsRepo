#define DATA_LENGTH 512
#define DATA AKWF_0459

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 0, 2, 1, 2, 2, 3, 3, 3, 4,
6, 6, 10, 12, 13, 16, 27, 38, 40, 39, 32, 27, 21, 17, 15, 16, 17, 19, 20, 20,
21, 21, 19, 18, 15, 13, 12, 10, 10, 10, 10, 10, 10, 10, 10, 10, 9, 9, 9, 8, 9,
8, 8, 9, 8, 8, 9, 9, 9, 9, 9, 9, 9, 9, 9, 9, 9, 10, 9, 9, 9, 10, 10, 10, 10, 10,
9, 10, 10, 10, 10, 10, 10, 10, 10, 10, 9, 10, 10, 9, 10, 9, 9, 9, 7, 5, -2, -7,
-19, -33, -65, -98, -108, -102, -84, -65, -46, -33, -25, -24, -26, -30, -35,
-37, -37, -37, -33, -27, -23, -18, -15, -12, -10, -9, -9, -8, -7, -6, -5, -4,
-1, -1, 1, 0, 2, 1, 2, 1, 2, 0, 0, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0,
-1, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 1, 1, 2, 2, 2, 2, 3, 4, 4, 5,
6, 8, 9, 13, 14, 20, 32, 39, 40, 37, 30, 23, 18, 16, 16, 15, 17, 19, 21, 21, 21,
20, 19, 16, 15, 12, 12, 10, 10, 11, 10, 11, 11, 11, 10, 9, 9, 9, 8, 8, 8, 8, 8,
9, 9, 9, 9, 9, 8, 8, 9, 8, 10, 10, 9, 9, 9, 10, 9, 9, 10, 10, 9, 10, 10, 10, 10,
10, 10, 10, 10, 10, 10, 9, 9, 10, 10, 9, 10, 9, 9, 10, 10, 9, 6, 2, -4, -13,
-24, -44, -81, -105, -107, -96, -76, -56, -40, -30, -24, -24, -28, -32, -35,
-38, -38, -35, -31, -26, -21, -17, -14, -11, -10, -8, -9, -8, -7, -6, -5, -2,
-2, 0, 0, 1, 1, 2, 2, 2, 1, 1, 1, 1, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, -1, -1,
0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 1, 1, 1, 1, 2, 3, 3, 3, 4, 5, 7,
8, 12, 14, 15, 25, 36, 40, 39, 34, 27, 21, 18, 16, 15, 17, 19, 19, 21, 21, 20,
19, 17, 15, 13, 12, 12, 11, 11, 11, 11, 10, 10, 10, 10, 9, 9, 8, 8, 9, 9, 9, 9,
8, 9, 9, 9, 8, 9, 9, 8, 8, 9, 9, 9, 9, 10, 9, 9, 9, 9, 9, 10, 11, 9, 10, 9, 10,
10, 9, 9, 10, 11, 9, 10, 11, 9, 10, 10, 10, 9, 9, 9, 7, 5, 0, -5, -17, -30, -57,
-93, -107, -104, -89, -68, -49, -36, -26, -24, -25, -29, -34, -36, -39, -37,
-34, -30, -23, -18, -15, -12, -10, -9, -9, -9, -8, -7, -6, -3, -2, 0, 0, 0, 2,
1, 1, 1, 2, 0, 0, 2, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, -1, 0, 0, 0, 0, -1, -1, -1,
-1, 0, 0, -1, -1, 0, -1, 0, };