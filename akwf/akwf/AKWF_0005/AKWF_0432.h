#define DATA_LENGTH 512
#define DATA AKWF_0432

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 67, 71, 45, 20, 11, 9, 10, 9, 9,
8, 7, 7, 6, 4, 3, 1, 1, 2, 4, 7, 8, 11, 13, 15, 17, 20, 22, 24, 24, 25, 25, 24,
23, 23, 23, 24, 24, 25, 26, 27, 29, 30, 31, 33, 34, 36, 37, 39, 39, 42, 43, 45,
46, 47, 50, 51, 53, 55, 56, 58, 60, 61, 62, 64, 66, 67, 69, 71, 72, 73, 75, 76,
77, 79, 81, 83, 83, 85, 86, 87, 88, 90, 91, 92, 93, 94, 96, 97, 98, 99, 99, 101,
102, 103, 104, 105, 105, 107, 108, 107, 109, 110, 110, 112, 112, 113, 113, 114,
114, 114, 116, 115, 115, 117, 117, 117, 118, 118, 118, 118, 118, 119, 118, 119,
119, 119, 119, 119, 118, 118, 119, 119, 118, 118, 118, 118, 117, 118, 117, 116,
116, 116, 116, 115, 114, 115, 114, 112, 111, 112, 110, 110, 109, 109, 108, 106,
107, 105, 105, 104, 102, 102, 101, 100, 99, 97, 96, 96, 95, 93, 92, 90, 89, 87,
86, 85, 84, 82, 81, 79, 79, 77, 75, 73, 73, 71, 70, 68, 66, 65, 64, 62, 60, 59,
57, 56, 54, 53, 51, 49, 47, 46, 45, 43, 41, 40, 38, 36, 34, 34, 33, 31, 29, 28,
28, 26, 24, 24, 23, 24, 23, 23, 25, 24, 26, 24, 22, 21, 19, 16, 14, 12, 10, 8,
6, 4, 2, 0, 2, 3, 6, 6, 8, 8, 7, 9, 9, 11, 15, 18, 27, 39, 55, 60, 31, -28, -70,
-70, -42, -19, -11, -10, -11, -9, -8, -8, -8, -7, -7, -5, -3, -1, -1, -2, -4,
-8, -8, -11, -12, -15, -17, -20, -22, -23, -24, -25, -25, -25, -24, -24, -23,
-24, -25, -25, -26, -27, -29, -30, -32, -33, -35, -36, -37, -39, -41, -42, -43,
-46, -47, -48, -50, -52, -53, -55, -56, -58, -60, -61, -62, -65, -65, -68, -69,
-70, -72, -74, -75, -76, -78, -79, -80, -82, -83, -84, -87, -87, -88, -89, -91,
-92, -94, -94, -96, -97, -98, -98, -100, -101, -103, -103, -105, -105, -105,
-107, -108, -108, -109, -110, -110, -112, -112, -112, -113, -113, -115, -115,
-115, -116, -116, -117, -117, -117, -117, -118, -118, -118, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -118, -120, -119, -119, -118, -118,
-118, -117, -117, -117, -116, -116, -116, -115, -114, -115, -113, -113, -112,
-111, -111, -110, -110, -108, -108, -108, -106, -106, -105, -103, -103, -102,
-100, -100, -99, -97, -96, -95, -94, -92, -92, -90, -89, -87, -87, -85, -84,
-82, -81, -79, -78, -77, -75, -73, -73, -71, -69, -68, -67, -65, -63, -62, -60,
-59, -56, -56, -54, -53, -50, -49, -48, -45, -45, -42, -41, -40, -38, -36, -35,
-33, -32, -31, -30, -28, -27, -25, -25, -24, -23, -23, -24, -24, -25, -25, -25,
-24, -23, -20, -19, -16, -14, -11, -9, -7, -6, -3, -2, -1, -1, -3, -6, -8, -8,
-8, -8, -9, -10, -12, -14, -20, -27, -42, -57, -60, -25, };