#define DATA_LENGTH 512
#define DATA AKWF_0477

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 17, 23, 28, 32, 37, 40, 45,
50, 55, 59, 64, 67, 73, 77, 80, 84, 89, 93, 96, 101, 104, 107, 110, 115, 118,
119, 118, 119, 119, 120, 120, 118, 119, 119, 118, 118, 119, 119, 118, 118, 120,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 118, 119, 119, 118, 119, 119, 119, 120, 117, 115, 112, 108, 106,
102, 99, 96, 92, 90, 85, 83, 78, 75, 71, 67, 64, 60, 55, 52, 47, 42, 38, 33, 30,
25, 21, 17, 13, 8, 3, -1, -5, -10, -15, -19, -23, -27, -31, -33, -36, -39, -41,
-45, -49, -52, -55, -59, -61, -64, -66, -69, -71, -73, -76, -78, -80, -82, -84,
-86, -89, -91, -93, -95, -97, -98, -100, -101, -103, -105, -106, -107, -107,
-109, -110, -110, -111, -113, -108, -95, -75, -58, -48, -44, -42, -42, -42, -41,
-39, -35, -31, -26, -23, -18, -14, -12, -9, -6, -5, -4, -3, -3, -3, -1, -2, -2,
-1, -2, -1, -1, -1, -1, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, 1, 0, 1, 4, 7, 10, 12, 16, 18, 22, 26, 29, 32, 36, 39, 43, 46, 49, 54, 57,
61, 63, 66, 69, 72, 75, 77, 80, 82, 85, 87, 89, 91, 94, 95, 98, 98, 101, 103,
103, 104, 105, 107, 107, 109, 110, 110, 112, 111, 113, 112, 113, 113, 112, 113,
113, 112, 111, 112, 111, 109, 109, 111, 117, 119, 119, 119, 119, 119, 119, 119,
115, 115, 111, 109, 108, 105, 102, 100, 98, 93, 91, 88, 84, 80, 76, 73, 70, 66,
62, 58, 54, 50, 45, 41, 37, 33, 28, 24, 20, 15, 11, 7, 2, -3, -6, -12, -15, -20,
-24, -29, -33, -37, -41, -45, -49, -54, -59, -62, -66, -70, -74, -77, -81, -85,
-88, -91, -94, -99, -101, -104, -108, -110, -113, -116, -118, -119, -119, -119,
-119, -118, -120, -119, -119, -120, -119, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -118, -119, -118, -119, -120, -117, -114, -111,
-108, -106, -102, -99, -97, -93, -90, -86, -82, -78, -75, -71, -68, -63, -59,
-56, -51, -48, -43, -38, -34, -29, -25, -22, -18, -12, -8, -4, 1, 5, 9, 13, 19,
16, 5, -6, -15, -22, -29, -33, -39, -45, -51, -55, -61, -67, -72, -78, -82, -87,
-92, -98, -102, -106, -110, -113, -117, -119, -119, -119, -118, -119, -120,
-119, -119, -119, -120, -119, -119, -120, -119, -120, -118, -118, -119, -120,
-120, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -118, -118,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -120, -119, -120,
-118, -116, -113, -110, -106, -103, -98, -95, -91, -88, -83, -79, -75, -71, -67,
-62, -58, -53, -48, -44, -39, -34, -30, -25, -20, -16, -10, -5, -1, };