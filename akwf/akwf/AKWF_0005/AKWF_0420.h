#define DATA_LENGTH 512
#define DATA AKWF_0420

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 11, 15, 18, 21, 25, 28, 31,
34, 36, 37, 38, 39, 37, 37, 34, 32, 29, 26, 21, 18, 14, 10, 6, 1, -2, -5, -8,
-11, -13, -14, -15, -16, -16, -15, -13, -13, -12, -10, -9, -8, -6, -5, -3, -3,
-2, -1, 0, 0, 1, 1, 2, 1, 3, 2, 2, 3, 3, 3, 4, 4, 4, 4, 4, 4, 5, 6, 7, 7, 6, 7,
8, 8, 9, 10, 10, 11, 10, 10, 13, 12, 12, 13, 14, 14, 14, 15, 16, 18, 18, 18, 19,
19, 18, 19, 18, 18, 17, 17, 15, 14, 13, 11, 10, 8, 7, 6, 4, 3, 1, 1, -1, -1, -2,
-3, -3, -3, -5, -5, -5, -6, -6, -6, -7, -7, -7, -7, -7, -9, -8, -9, -9, -10,
-10, -10, -22, -64, -100, -111, -120, -117, -108, -94, -78, -59, -40, -22, -6,
8, 19, 28, 34, 37, 39, 37, 34, 29, 24, 19, 12, 8, 2, -3, -6, -10, -12, -13, -15,
-14, -15, -14, -14, -13, -12, -12, -10, -10, -9, -8, -7, -7, -6, -5, -4, -3, -1,
2, 4, 6, 10, 12, 16, 18, 22, 25, 28, 31, 34, 36, 37, 37, 39, 38, 35, 34, 30, 28,
25, 20, 16, 12, 8, 4, 0, -3, -6, -10, -11, -13, -14, -16, -15, -15, -14, -14,
-13, -12, -10, -9, -7, -7, -4, -3, -2, -2, -1, 0, 1, 1, 1, 2, 2, 2, 3, 2, 3, 3,
4, 3, 3, 5, 5, 5, 5, 6, 6, 6, 7, 7, 8, 8, 8, 4, -11, -47, -66, -74, -79, -75,
-70, -59, -47, -34, -22, -10, 2, 12, 19, 24, 28, 29, 30, 29, 27, 23, 18, 15, 11,
7, 4, 0, -3, -5, -6, -7, -8, -8, -8, -9, -8, -7, -7, -6, -7, -6, -7, -6, -6, -7,
-7, -8, -8, -9, -9, -8, -8, -7, -8, -5, -3, -2, 1, 5, 7, 10, 14, 17, 21, 23, 28,
31, 33, 36, 38, 38, 39, 39, 38, 36, 32, 29, 26, 22, 18, 14, 10, 5, 3, -2, -5,
-8, -11, -12, -14, -15, -15, -16, -15, -14, -13, -12, -11, -9, -9, -8, -6, -4,
-3, -2, -1, 0, 1, 0, 2, 1, 2, 2, 3, 3, 3, 3, 3, 3, 4, 4, 4, 4, 5, 6, 5, 3, -11,
-33, -55, -81, -93, -103, -104, -101, -95, -84, -72, -57, -43, -29, -17, -5, 4,
11, 15, 19, 21, 21, 19, 17, 15, 11, 9, 5, 3, 0, -2, -3, -3, -4, -2, -2, 0, 1, 3,
5, 7, 9, 12, 13, 15, 17, 18, 19, 21, 22, 21, 21, 21, 21, 20, 18, 18, 17, 16, 14,
13, 11, 12, 10, 9, 9, 8, 8, 8, 7, 7, 7, 6, 6, 6, 5, 5, 6, 5, 4, 4, 4, 4, 3, 2,
2, 3, 1, 1, 1, 1, 0, -1, -1, -1, -3, -2, -3, -4, -5, -6, -6, -6, -8, -7, -8, -9,
-10, -9, -9, -10, -9, -9, -9, -8, -7, -4, -2, 0, };