#define DATA_LENGTH 512
#define DATA AKWF_0484

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 3, 3, 4, 5, 6, 7, 8, 8, 9,
10, 10, 12, 12, 12, 14, 14, 14, 15, 16, 17, 18, 19, 19, 20, 21, 21, 22, 23, 22,
24, 24, 25, 25, 26, 26, 26, 27, 28, 29, 29, 30, 30, 30, 30, 32, 31, 32, 33, 33,
33, 33, 33, 35, 35, 35, 35, 36, 36, 37, 36, 37, 37, 37, 37, 38, 39, 39, 40, 40,
40, 40, 40, 41, 41, 42, 43, 42, 44, 44, 44, 44, 45, 46, 46, 46, 47, 48, 48, 48,
49, 49, 50, 51, 52, 52, 53, 53, 53, 54, 55, 55, 56, 57, 57, 57, 59, 59, 59, 59,
61, 61, 61, 62, 63, 63, 64, 65, 66, 66, 67, 67, 68, 68, 68, 70, 71, 70, 71, 72,
72, 73, 74, 73, 75, 75, 75, 76, 76, 77, 78, 78, 79, 79, 80, 80, 81, 81, 82, 82,
82, 83, 84, 84, 85, 85, 85, 86, 87, 87, 87, 88, 88, 89, 89, 89, 90, 90, 90, 91,
91, 91, 91, 91, 92, 92, 92, 93, 93, 92, 92, 94, 94, 93, 94, 93, 94, 94, 93, 93,
94, 92, 94, 92, 93, 93, 92, 92, 92, 91, 91, 91, 90, 90, 90, 89, 89, 88, 88, 87,
86, 86, 86, 85, 84, 83, 84, 82, 82, 82, 81, 80, 79, 79, 78, 77, 76, 75, 75, 73,
72, 71, 70, 69, 68, 68, 67, 65, 65, 63, 63, 62, 60, 58, 58, 56, 55, 54, 53, 52,
51, 50, 49, 47, 46, 44, 43, 42, 41, 39, 38, 37, 35, 34, 33, 32, 29, 28, 26, 24,
23, 22, 21, 19, 17, 16, 15, 13, 12, 9, 8, 7, 6, 3, 1, 1, -1, -2, -5, -6, -9,
-10, -11, -12, -15, -16, -18, -20, -21, -23, -24, -26, -29, -29, -31, -32, -35,
-37, -37, -39, -41, -42, -45, -46, -47, -49, -51, -52, -54, -56, -58, -58, -61,
-62, -63, -64, -66, -68, -69, -71, -72, -74, -74, -76, -78, -80, -81, -82, -82,
-85, -86, -86, -88, -89, -91, -92, -93, -95, -95, -97, -97, -99, -99, -100,
-101, -102, -103, -104, -105, -106, -107, -108, -109, -109, -110, -110, -111,
-112, -112, -113, -114, -114, -115, -115, -116, -116, -116, -117, -118, -118,
-118, -117, -119, -118, -119, -118, -119, -118, -119, -119, -119, -119, -119,
-119, -118, -118, -119, -118, -117, -118, -118, -117, -117, -116, -116, -116,
-116, -115, -114, -114, -112, -112, -111, -111, -111, -109, -109, -108, -107,
-107, -106, -105, -104, -103, -102, -101, -100, -99, -98, -98, -96, -95, -94,
-92, -92, -90, -90, -88, -86, -85, -84, -82, -82, -80, -79, -77, -76, -74, -73,
-72, -71, -69, -68, -65, -64, -63, -61, -60, -57, -56, -55, -54, -52, -50, -49,
-47, -46, -44, -42, -41, -39, -38, -37, -35, -34, -33, -32, -31, -29, -29, -28,
-26, -25, -24, -22, -21, -21, -20, -19, -18, -17, -16, -14, -14, -13, -11, -11,
-10, -9, -8, -8, -6, -6, -5, -4, -4, -3, -3, -1, -1, };