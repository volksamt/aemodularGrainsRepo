#define DATA_LENGTH 512
#define DATA AKWF_0403

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 4, 5, 6, 8, 9, 10, 11, 13,
13, 15, 16, 17, 18, 19, 21, 22, 22, 24, 25, 26, 28, 29, 30, 32, 32, 33, 35, 35,
37, 38, 38, 39, 41, 42, 43, 45, 46, 47, 49, 49, 50, 51, 52, 54, 55, 56, 57, 58,
59, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 71, 72, 72, 74, 76, 76, 78, 78, 79,
80, 81, 81, 83, 83, 85, 86, 87, 87, 88, 89, 90, 91, 91, 93, 94, 94, 95, 95, 97,
97, 97, 98, 99, 100, 101, 101, 102, 102, 103, 104, 104, 105, 106, 106, 107, 107,
108, 109, 108, 109, 111, 112, 111, 112, 112, 112, 113, 113, 115, 114, 115, 115,
116, 116, 116, 116, 116, 117, 118, 117, 117, 118, 118, 118, 119, 119, 119, 119,
119, 119, 118, 119, 120, 119, 120, 120, 119, 119, 119, 118, 118, 119, 118, 119,
118, 118, 117, 118, 116, 117, 116, 116, 116, 116, 116, 115, 114, 114, 113, 113,
112, 112, 112, 110, 111, 109, 109, 108, 107, 106, 105, 105, 104, 103, 103, 102,
101, 99, 99, 98, 97, 95, 95, 93, 93, 90, 90, 89, 87, 86, 84, 83, 82, 81, 79, 78,
77, 75, 73, 72, 70, 69, 67, 66, 63, 62, 61, 59, 57, 57, 54, 53, 50, 50, 48, 46,
44, 41, 40, 39, 37, 35, 34, 32, 30, 29, 26, 24, 23, 20, 19, 18, 16, 13, 12, 10,
8, 6, 4, 3, 0, -1, -3, -4, -7, -8, -10, -12, -14, -15, -17, -19, -20, -22, -24,
-26, -28, -30, -32, -33, -34, -36, -38, -40, -41, -43, -44, -45, -47, -49, -50,
-52, -54, -55, -56, -58, -60, -60, -62, -65, -65, -66, -67, -68, -70, -71, -73,
-74, -75, -76, -78, -79, -80, -82, -83, -84, -85, -86, -87, -87, -89, -91, -91,
-92, -93, -94, -95, -95, -96, -97, -98, -100, -100, -101, -102, -102, -104,
-105, -105, -106, -106, -107, -108, -109, -109, -110, -110, -110, -111, -111,
-113, -113, -113, -114, -114, -114, -115, -115, -116, -116, -116, -116, -117,
-117, -117, -118, -118, -118, -118, -118, -117, -118, -119, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -117, -118, -118, -117, -117, -117, -117,
-117, -116, -115, -116, -115, -115, -115, -115, -115, -113, -113, -113, -112,
-111, -111, -110, -110, -109, -109, -108, -107, -107, -106, -106, -105, -105,
-103, -104, -103, -102, -101, -101, -100, -99, -98, -98, -97, -96, -95, -95,
-93, -93, -91, -91, -89, -89, -87, -86, -86, -85, -84, -83, -82, -81, -81, -79,
-78, -77, -77, -75, -74, -74, -73, -71, -71, -69, -68, -67, -67, -66, -64, -63,
-61, -61, -60, -59, -59, -58, -56, -56, -54, -53, -52, -51, -50, -49, -47, -48,
-45, -45, -43, -43, -41, -41, -39, -39, -38, -37, -35, -35, -34, -32, -30, -30,
-29, -28, -27, -26, -24, -24, -22, -21, -19, -19, -18, -17, -15, -15, -14, -12,
-11, -10, -9, -8, -7, -6, -5, -3, -3, -1, 0, };