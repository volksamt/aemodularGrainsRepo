#define DATA_LENGTH 512
#define DATA AKWF_0404

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 14, 20, 24, 25, 30, 32, 33,
36, 39, 42, 45, 47, 49, 51, 51, 52, 53, 55, 58, 59, 60, 62, 63, 66, 67, 66, 68,
70, 71, 73, 74, 74, 75, 76, 75, 77, 78, 78, 79, 80, 81, 81, 82, 81, 82, 83, 83,
83, 84, 84, 85, 85, 87, 87, 88, 88, 89, 90, 91, 91, 93, 93, 94, 94, 96, 97, 98,
98, 98, 100, 103, 103, 105, 105, 107, 106, 106, 107, 108, 107, 109, 109, 110,
110, 111, 111, 112, 111, 113, 113, 112, 113, 112, 113, 113, 114, 114, 115, 114,
115, 116, 116, 116, 117, 116, 117, 117, 117, 117, 116, 117, 117, 117, 118, 118,
118, 117, 118, 118, 119, 119, 118, 118, 119, 119, 109, 109, 110, 109, 110, 109,
110, 109, 110, 110, 110, 110, 109, 110, 110, 109, 109, 110, 109, 109, 109, 109,
108, 109, 109, 108, 108, 109, 109, 108, 109, 108, 107, 107, 106, 106, 106, 106,
106, 106, 106, 107, 106, 106, 105, 105, 104, 105, 104, 104, 103, 103, 103, 103,
102, 102, 101, 100, 99, 100, 99, 99, 99, 98, 98, 97, 97, 97, 95, 95, 95, 95, 94,
93, 93, 93, 92, 91, 90, 90, 89, 89, 89, 87, 87, 86, 86, 84, 84, 84, 83, 82, 81,
81, 78, 77, 76, 77, 75, 74, 72, 72, 71, 69, 68, 68, 67, 65, 65, 63, 62, 59, 56,
52, 49, 46, 43, 40, 38, 35, 32, 30, 28, 22, 19, 13, 8, 3, -14, -17, -20, -25,
-27, -29, -30, -34, -36, -39, -41, -44, -46, -49, -50, -52, -54, -56, -58, -61,
-63, -65, -66, -68, -69, -71, -73, -73, -74, -76, -77, -79, -80, -81, -83, -82,
-83, -83, -84, -84, -86, -87, -86, -86, -87, -89, -89, -89, -90, -90, -91, -92,
-92, -93, -94, -94, -95, -95, -95, -98, -98, -98, -99, -100, -100, -102, -102,
-103, -103, -103, -104, -104, -105, -105, -105, -105, -106, -107, -107, -107,
-108, -108, -108, -109, -109, -110, -109, -110, -109, -110, -110, -109, -110,
-111, -110, -110, -110, -111, -110, -110, -111, -111, -111, -111, -111, -111,
-110, -111, -111, -111, -111, -111, -111, -112, -112, -112, -111, -111, -110,
-111, -110, -110, -110, -110, -109, -110, -109, -110, -120, -119, -119, -119,
-119, -119, -117, -118, -118, -117, -118, -117, -117, -117, -117, -115, -114,
-115, -115, -114, -114, -113, -114, -113, -112, -112, -111, -111, -110, -110,
-109, -109, -108, -107, -108, -107, -106, -105, -105, -104, -104, -104, -103,
-102, -103, -102, -101, -100, -101, -101, -100, -100, -100, -99, -100, -100,
-98, -98, -99, -97, -96, -98, -98, -98, -98, -97, -96, -96, -95, -95, -94, -93,
-92, -92, -91, -90, -90, -88, -88, -86, -86, -85, -84, -84, -83, -82, -80, -79,
-78, -76, -75, -74, -73, -73, -71, -70, -68, -67, -66, -65, -63, -61, -58, -58,
-55, -54, -53, -53, -52, -51, -50, -48, -48, -49, -48, -47, -45, -45, -42, -38,
-36, -32, -31, -24, -18, -14, -8, -3, };