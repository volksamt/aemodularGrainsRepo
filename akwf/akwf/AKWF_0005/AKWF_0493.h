#define DATA_LENGTH 512
#define DATA AKWF_0493

const PROGMEM int8_t DATA[DATA_LENGTH] = {-51, -113, -118, -111, -102, -97, -93,
-90, -87, -86, -84, -86, -87, -91, -93, -96, -98, -99, -100, -101, -101, -100,
-101, -100, -100, -100, -98, -98, -98, -98, -97, -97, -97, -97, -97, -96, -97,
-97, -97, -97, -97, -97, -96, -97, -96, -97, -96, -96, -96, -96, -96, -96, -96,
-97, -97, -96, -96, -97, -96, -96, -96, -96, -96, -96, -97, -97, -96, -96, -96,
-96, -96, -96, -97, -96, -97, -95, -97, -96, -97, -97, -98, -95, -71, -63, -65,
-67, -69, -70, -72, -73, -73, -73, -73, -73, -73, -72, -72, -71, -71, -71, -70,
-71, -71, -71, -71, -71, -72, -71, -72, -72, -72, -71, -72, -72, -73, -72, -73,
-72, -72, -72, -73, -73, -72, -73, -73, -73, -73, -73, -73, -72, -72, -72, -72,
-72, -73, -72, -72, -73, -73, -72, -72, -73, -73, -72, -72, -73, -73, -73, -72,
-74, -53, -39, -40, -40, -43, -44, -45, -46, -46, -46, -46, -46, -45, -45, -44,
-45, -44, -43, -43, -44, -44, -44, -44, -44, -43, -44, -44, -44, -44, -45, -44,
-45, -45, -44, -45, -45, -45, -44, -44, -45, -45, -45, -44, -43, -45, -45, -44,
-44, -45, -44, -45, -44, -45, -45, -45, -44, -44, -44, -45, -45, -44, -44, -44,
-45, -44, -45, -43, -46, -31, -11, -11, -12, -14, -15, -16, -16, -17, -17, -17,
-16, -16, -16, -14, -15, -15, -15, -14, -14, -14, -14, -15, -15, -15, -15, -14,
-14, -15, -15, -15, -14, -15, -15, -15, -15, -15, -15, -15, -14, -15, -15, -15,
-16, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -16,
-16, -15, -15, -15, -16, -15, -15, -16, -15, -15, -15, -16, -15, -16, -14, -18,
-3, 18, 18, 19, 16, 15, 13, 13, 12, 14, 14, 14, 14, 14, 14, 15, 16, 15, 16, 15,
15, 15, 16, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 14, 14, 15, 14,
14, 14, 15, 15, 14, 14, 14, 15, 15, 15, 15, 15, 15, 14, 15, 14, 15, 15, 15, 15,
15, 14, 14, 15, 14, 15, 14, 15, 15, 15, 14, 15, 14, 15, 15, 14, 15, 15, 15, 14,
16, 12, 29, 48, 47, 48, 45, 45, 43, 42, 43, 43, 43, 43, 43, 44, 44, 44, 44, 45,
45, 45, 45, 45, 44, 44, 44, 45, 44, 45, 45, 44, 45, 44, 44, 44, 44, 44, 44, 44,
44, 44, 44, 44, 44, 45, 44, 45, 44, 44, 45, 45, 44, 44, 44, 44, 44, 44, 44, 44,
44, 44, 44, 44, 44, 44, 44, 43, 46, 41, 52, 76, 77, 77, 74, 74, 72, 70, 71, 70,
70, 71, 70, 71, 72, 72, 72, 72, 72, 72, 72, 73, 72, 71, 71, 72, 72, 72, 72, 72,
71, 71, 72, 71, 72, 72, 72, 71, 71, 72, 72, 71, 72, 71, 72, 71, 72, 72, 71, 72,
72, 72, 72, 72, 71, 72, 71, 73, 71, 73, 71, 73, 70, 73, 70, 74, 68, 76, 61, };