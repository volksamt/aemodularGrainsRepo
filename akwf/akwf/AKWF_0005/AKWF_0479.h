#define DATA_LENGTH 512
#define DATA AKWF_0479

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 12, 16, 20, 24, 28, 32, 36,
39, 42, 45, 49, 53, 55, 58, 61, 65, 68, 69, 71, 73, 76, 78, 81, 82, 83, 85, 87,
89, 89, 89, 90, 91, 91, 92, 91, 90, 90, 90, 90, 89, 87, 87, 86, 83, 83, 80, 80,
77, 75, 72, 70, 69, 66, 63, 62, 60, 58, 56, 55, 53, 51, 50, 49, 46, 45, 42, 42,
40, 38, 37, 35, 35, 31, 31, 28, 28, 25, 23, 20, 19, 16, 15, 12, 9, 7, 5, 3, 0,
-3, -5, -9, -11, -15, -18, -19, -24, -26, -30, -33, -36, -40, -42, -46, -49,
-51, -56, -59, -62, -66, -69, -71, -74, -78, -80, -83, -87, -90, -91, -94, -96,
-99, -101, -104, -106, -107, -109, -111, -112, -114, -115, -116, -117, -118,
-118, -118, -118, -119, -119, -118, -118, -118, -117, -116, -115, -113, -112,
-111, -109, -108, -106, -103, -101, -99, -96, -92, -90, -88, -84, -81, -78, -73,
-70, -66, -62, -58, -54, -50, -46, -42, -38, -33, -29, -25, -20, -17, -11, -7,
-3, 1, 5, 9, 13, 17, 20, 22, 26, 29, 31, 35, 36, 38, 39, 42, 44, 45, 46, 47, 49,
49, 50, 52, 52, 54, 53, 54, 55, 56, 55, 56, 56, 57, 57, 57, 57, 57, 58, 57, 57,
57, 57, 58, 57, 59, 57, 58, 58, 58, 59, 59, 59, 59, 60, 60, 60, 60, 60, 59, 60,
60, 59, 60, 60, 60, 60, 60, 59, 60, 61, 61, 61, 60, 61, 60, 60, 59, 58, 59, 58,
57, 57, 56, 56, 55, 54, 54, 53, 52, 51, 50, 49, 48, 47, 46, 44, 43, 41, 41, 39,
37, 35, 34, 33, 31, 29, 27, 26, 24, 22, 20, 18, 15, 14, 12, 10, 8, 6, 4, 2, 0,
-2, -4, -6, -8, -10, -12, -15, -17, -19, -21, -23, -26, -28, -29, -31, -34, -36,
-38, -40, -41, -44, -45, -47, -48, -50, -52, -53, -54, -55, -56, -58, -59, -60,
-60, -61, -61, -62, -62, -62, -62, -63, -63, -63, -62, -62, -61, -60, -59, -59,
-58, -57, -56, -54, -54, -52, -51, -49, -48, -46, -44, -43, -41, -40, -36, -35,
-33, -30, -29, -27, -24, -22, -20, -17, -14, -12, -10, -7, -5, -3, 0, 1, 4, 6,
8, 11, 13, 15, 18, 19, 22, 23, 26, 28, 30, 31, 34, 34, 36, 38, 39, 40, 42, 43,
44, 44, 45, 47, 47, 48, 48, 49, 49, 49, 49, 49, 50, 50, 50, 49, 49, 48, 48, 47,
47, 46, 45, 44, 43, 42, 40, 39, 38, 38, 36, 34, 33, 30, 29, 27, 24, 21, 19, 17,
14, 11, 8, 4, 2, -1, -5, -9, -12, -15, -19, -22, -26, -30, -32, -35, -39, -42,
-44, -47, -50, -53, -55, -57, -59, -62, -64, -66, -68, -68, -71, -70, -72, -73,
-73, -73, -73, -73, -72, -72, -71, -70, -70, -68, -67, -65, -63, -62, -60, -58,
-54, -52, -50, -47, -44, -41, -38, -34, -32, -28, -25, -21, -17, -13, -9, -5,
-2, };