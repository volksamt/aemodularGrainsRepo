#define DATA_LENGTH 512
#define DATA AKWF_0424

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 13, 16, 17, 18, 18, 19, 19, 20,
21, 23, 26, 27, 29, 30, 31, 32, 31, 31, 31, 31, 32, 32, 33, 34, 33, 34, 34, 32,
34, 32, 33, 32, 32, 32, 32, 32, 32, 32, 31, 30, 30, 30, 28, 29, 28, 28, 27, 27,
26, 25, 26, 25, 24, 24, 23, 22, 21, 21, 20, 20, 20, 19, 18, 18, 17, 17, 15, 16,
16, 14, 14, 14, 13, 12, 12, 12, 11, 11, 11, 10, 9, 9, 9, 9, 8, 8, 8, 8, 8, 6, 7,
7, 5, 6, 5, 5, 5, 5, 5, 4, 4, 5, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 3, 3, 4, 3, 3,
3, 3, 3, 3, 3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, -3, -26, -52, -69, -75,
-72, -66, -58, -51, -45, -36, -28, -23, -22, -26, -27, -26, -22, -17, -12, -8,
-5, -2, 0, 0, 0, -1, -2, -2, 0, 2, 3, 5, 6, 8, 8, 9, 9, 9, 9, 10, 11, 12, 12,
13, 14, 14, 15, 14, 15, 15, 15, 15, 15, 15, 15, 16, 16, 16, 16, 16, 16, 16, 16,
16, 15, 15, 15, 15, 15, 15, 14, 15, 15, 14, 14, 15, 14, 14, 13, 13, 13, 13, 13,
13, 12, 12, 12, 12, 11, 11, 11, 10, 10, 10, 10, 11, 10, 10, 10, 9, 10, 8, 8, 9,
8, 8, 8, 8, 8, 7, 8, 8, 7, 8, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 5,
4, 5, 5, 5, 6, 4, 4, 5, 4, 5, 5, 4, 4, 5, 5, 4, 5, 4, 5, 5, 4, 5, 5, 4, 4, 4, 4,
5, 4, 5, 4, 5, 4, 4, 5, 4, 5, 4, 3, -9, -37, -60, -72, -74, -70, -62, -54, -49,
-41, -33, -26, -21, -23, -25, -25, -23, -20, -15, -11, -6, -4, 1, 2, 2, 0, -1,
-1, 0, 2, 3, 5, 6, 7, 8, 9, 9, 10, 10, 10, 10, 11, 12, 12, 13, 14, 15, 14, 14,
14, 15, 15, 15, 15, 16, 15, 16, 15, 16, 15, 15, 16, 15, 16, 15, 16, 14, 15, 15,
15, 15, 14, 14, 15, 15, 14, 13, 13, 14, 13, 12, 13, 13, 12, 12, 12, 12, 11, 12,
11, 11, 11, 11, 11, 11, 10, 10, 9, 10, 9, 9, 8, 9, 8, 9, 8, 8, 8, 8, 8, 7, 7, 7,
7, 6, 7, 7, 6, 6, 5, 6, 6, 7, 6, 5, 6, 6, 5, 6, 5, 6, 5, 5, 4, 5, 5, 4, 5, 4, 5,
4, 5, 5, 4, 5, 5, 5, 5, 5, 5, 4, 4, 4, 5, 4, 4, 5, 4, 4, 4, 5, 5, 4, 5, 4, 5, 5,
5, 4, 6, -6, -54, -97, -115, -120, -118, -115, -109, -103, -96, -85, -71, -61,
-59, -62, -66, -64, -60, -50, -41, -31, -22, -13, -8, -5, -7, -11, -13, -12,
-10, -5, -1, };