#define DATA_LENGTH 512
#define DATA AKWF_0463

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 18, 32, 41, 50, 57, 67, 76, 89,
100, 110, 117, 120, 116, 109, 98, 87, 73, 62, 52, 43, 36, 30, 24, 17, 8, 0, -10,
-20, -28, -36, -41, -46, -46, -47, -48, -48, -48, -48, -49, -49, -50, -49, -47,
-45, -42, -40, -36, -33, -30, -27, -25, -23, -20, -20, -17, -16, -15, -13, -12,
-10, -8, -8, -6, -7, -7, -6, -7, -6, -5, -5, -4, -3, -2, -2, -1, -1, 0, 2, 2, 4,
4, 5, 7, 8, 9, 10, 10, 12, 13, 14, 14, 16, 16, 17, 17, 18, 17, 18, 17, 17, 17,
17, 17, 17, 16, 15, 14, 13, 12, 12, 10, 10, 9, 8, 7, 6, 5, 5, 4, 2, 1, 0, 0, -1,
-2, -2, -2, -3, -3, -4, -4, -5, -6, -6, -6, -6, -6, -6, -7, -7, -7, -7, -7, -7,
-7, -7, -7, -7, -7, -6, -6, -7, -6, -6, -5, -6, -7, -11, -16, -26, -38, -48,
-56, -59, -57, -49, -39, -25, -11, 1, 13, 21, 28, 32, 36, 40, 43, 48, 53, 58,
62, 64, 63, 59, 55, 47, 40, 33, 25, 20, 16, 12, 8, 4, 1, -3, -7, -12, -15, -19,
-22, -23, -25, -25, -24, -23, -22, -23, -22, -21, -21, -21, -20, -19, -18, -15,
-14, -13, -11, -10, -9, -8, -7, -6, -6, -5, -6, -5, -4, -4, -3, -4, -3, -2, -4,
-4, -3, -4, -4, -3, -3, -4, -3, -2, -2, -2, -2, -1, 0, 0, 1, 2, 2, 3, 4, 5, 5,
5, 6, 6, 6, 7, 7, 8, 7, 7, 7, 9, 8, 8, 8, 9, 8, 8, 7, 6, 6, 6, 6, 5, 5, 4, 4, 4,
3, 3, 2, 2, 1, 2, 1, 1, 0, -1, 0, 0, -2, -1, -2, -2, -2, -1, -2, -3, -2, -2, -3,
-3, -2, -2, -3, -4, -2, -3, -3, -3, -3, -3, -3, -2, -3, -3, -3, -3, -2, -3, -3,
-5, -10, -17, -28, -39, -49, -57, -58, -54, -45, -33, -18, -5, 7, 18, 24, 30,
34, 37, 41, 45, 50, 55, 60, 63, 64, 61, 56, 50, 43, 35, 28, 21, 16, 13, 8, 5, 1,
-3, -6, -10, -15, -18, -22, -25, -25, -27, -27, -25, -25, -24, -24, -23, -22,
-22, -22, -20, -20, -18, -16, -14, -12, -11, -10, -9, -7, -7, -6, -6, -5, -4,
-4, -4, -4, -2, -3, -3, -2, -3, -3, -2, -3, -2, -2, -2, -2, -2, -1, -1, 0, -1,
-1, 1, 2, 2, 2, 2, 4, 5, 5, 5, 5, 6, 8, 7, 8, 7, 7, 8, 8, 8, 8, 8, 8, 8, 9, 7,
7, 6, 7, 6, 6, 5, 5, 4, 4, 3, 3, 3, 2, 1, 1, 1, 0, 0, 0, -1, -2, 0, -1, -2, -2,
-2, -2, -2, -3, -2, -3, -3, -3, -3, -3, -4, -4, -2, -3, -4, -3, -3, -3, -2, -3,
-4, -3, -3, -2, -3, -3, -2, -3, -6, -12, -24, -40, -59, -77, -89, -95, -94, -83,
-70, -52, -32, -12, };