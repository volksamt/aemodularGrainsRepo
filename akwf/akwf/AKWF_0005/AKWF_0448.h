#define DATA_LENGTH 512
#define DATA AKWF_0448

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 49, 66, 78, 83, 88, 85, 77, 62,
46, 39, 45, 59, 75, 88, 98, 107, 112, 115, 116, 115, 111, 100, 77, 44, 17, 0, 1,
27, 54, 75, 89, 101, 108, 113, 116, 117, 114, 108, 94, 67, 36, 14, 4, 12, 34,
56, 71, 84, 91, 96, 96, 90, 71, 33, -6, -36, -53, -64, -66, -58, -22, 23, 53,
74, 87, 97, 103, 106, 106, 101, 90, 71, 47, 31, 28, 42, 59, 75, 87, 96, 102,
105, 104, 99, 80, 41, -3, -35, -56, -68, -75, -75, -65, -33, 9, 40, 58, 70, 75,
72, 55, 16, -24, -51, -69, -80, -87, -89, -88, -79, -61, -35, -12, -2, -12, -37,
-59, -77, -90, -100, -105, -108, -109, -105, -93, -57, -9, 29, 54, 70, 80, 84,
86, 80, 67, 42, 16, 1, 3, 23, 48, 66, 81, 92, 99, 103, 104, 100, 88, 56, 14,
-20, -43, -56, -63, -59, -36, 5, 39, 61, 76, 84, 90, 88, 78, 48, 5, -30, -53,
-67, -76, -81, -77, -68, -48, -24, -5, 0, -17, -42, -64, -81, -94, -103, -109,
-114, -115, -113, -107, -91, -53, -11, 20, 40, 51, 53, 42, 10, -27, -51, -67,
-77, -83, -82, -76, -57, -26, 3, 22, 29, 19, -14, -46, -69, -85, -96, -105,
-109, -112, -113, -109, -101, -80, -47, -19, 1, 4, -15, -44, -66, -83, -95,
-104, -108, -113, -113, -112, -106, -97, -81, -68, -63, -68, -79, -90, -100,
-108, -114, -117, -118, -118, -114, -101, -63, -15, 24, 51, 67, 78, 86, 87, 84,
76, 61, 45, 38, 47, 62, 77, 89, 99, 107, 112, 115, 117, 115, 109, 98, 74, 41,
15, 0, 3, 29, 56, 77, 91, 101, 109, 114, 116, 117, 114, 108, 92, 64, 34, 12, 3,
14, 36, 58, 73, 85, 93, 96, 94, 89, 68, 29, -10, -37, -55, -64, -66, -54, -16,
28, 55, 75, 88, 98, 103, 106, 105, 100, 89, 69, 45, 30, 29, 45, 61, 77, 88, 96,
102, 105, 104, 97, 76, 35, -7, -37, -57, -69, -75, -74, -62, -28, 13, 42, 59,
70, 75, 70, 52, 11, -27, -53, -70, -81, -87, -89, -86, -77, -58, -31, -12, -3,
-15, -39, -61, -78, -91, -100, -107, -110, -110, -105, -90, -51, -4, 32, 56, 71,
80, 85, 86, 79, 64, 39, 14, 0, 4, 26, 50, 68, 83, 92, 100, 104, 104, 99, 85, 51,
10, -24, -45, -58, -62, -58, -34, 10, 42, 64, 78, 86, 89, 87, 76, 44, 0, -33,
-55, -68, -76, -79, -76, -66, -46, -21, -4, -1, -19, -44, -66, -83, -94, -104,
-110, -114, -115, -113, -106, -87, -48, -8, 24, 43, 52, 54, 40, 5, -30, -53,
-69, -78, -83, -81, -74, -54, -23, 6, 23, 29, 17, -17, -48, -71, -86, -97, -105,
-110, -114, -113, -109, -99, -77, -44, -15, 2, 3, -19, -46, -68, -84, -96, -104,
-109, -113, -114, -111, -105, -95, -81, -67, -62, -68, -80, -92, -101, -109,
-114, -118, -120, -119, -113, -98, -57, -12, };