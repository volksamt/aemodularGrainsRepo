#define DATA_LENGTH 512
#define DATA AKWF_0494

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 0, -1, -4, -5, -1, 5, 7, 8, 4,
4, 6, 9, 12, 14, 14, 15, 19, 19, 17, 13, 11, 14, 20, 25, 25, 21, 17, 18, 22, 23,
25, 27, 28, 29, 31, 30, 27, 27, 30, 31, 28, 23, 16, 16, 16, 16, 16, 15, 13, 12,
7, 3, -3, -3, -4, -4, -1, 0, 2, 4, 7, 9, 9, 7, 7, 6, 6, 9, 15, 17, 17, 19, 24,
27, 26, 23, 22, 22, 19, 17, 17, 15, 13, 16, 22, 28, 30, 27, 25, 22, 23, 27, 35,
41, 42, 40, 43, 48, 52, 53, 52, 54, 62, 65, 64, 65, 69, 68, 70, 74, 73, 70, 68,
66, 66, 65, 61, 60, 61, 61, 62, 60, 52, 45, 46, 48, 48, 42, 36, 31, 31, 30, 26,
25, 26, 22, 18, 14, 16, 16, 12, 9, 9, 10, 9, 10, 10, 4, 0, 0, -1, -3, -5, -5,
-5, -4, 1, 5, 9, 15, 15, 14, 14, 16, 19, 21, 21, 20, 24, 27, 27, 27, 26, 28, 30,
31, 28, 26, 26, 27, 32, 39, 44, 47, 50, 56, 63, 67, 68, 69, 73, 79, 86, 93, 99,
105, 110, 116, 118, 119, 117, 112, 107, 102, 98, 95, 98, 96, 89, 81, 73, 70, 64,
50, 36, 24, 13, 5, -4, -11, -15, -22, -31, -38, -44, -47, -50, -52, -56, -62,
-68, -72, -75, -84, -93, -94, -90, -86, -85, -82, -75, -72, -75, -78, -77, -72,
-73, -71, -68, -64, -60, -59, -61, -57, -50, -44, -39, -36, -36, -34, -29, -22,
-16, -10, -3, 2, 6, 10, 16, 27, 33, 39, 43, 43, 47, 53, 59, 66, 73, 78, 79, 78,
76, 71, 67, 67, 65, 65, 63, 58, 56, 54, 54, 55, 53, 49, 46, 42, 38, 31, 27, 25,
22, 17, 11, 6, 0, -9, -20, -27, -34, -44, -52, -56, -54, -54, -58, -63, -68,
-71, -73, -73, -71, -75, -82, -86, -89, -88, -84, -85, -86, -85, -81, -83, -86,
-84, -79, -74, -67, -58, -51, -46, -44, -41, -39, -34, -26, -16, -8, -6, -4, -4,
-4, -4, -3, 1, 6, 13, 18, 21, 19, 15, 13, 15, 21, 25, 24, 24, 21, 17, 17, 20,
24, 27, 27, 24, 19, 20, 22, 25, 28, 31, 33, 36, 37, 37, 34, 31, 30, 24, 17, 15,
14, 14, 15, 13, 10, 5, -5, -15, -24, -30, -29, -31, -36, -35, -35, -43, -53,
-58, -63, -65, -67, -68, -69, -71, -79, -82, -83, -86, -89, -94, -96, -97, -101,
-100, -95, -93, -90, -86, -80, -75, -77, -82, -83, -81, -79, -77, -78, -81, -82,
-78, -75, -74, -73, -71, -71, -68, -68, -69, -67, -67, -70, -71, -68, -63, -60,
-55, -50, -43, -39, -38, -39, -37, -31, -23, -17, -15, -13, -14, -15, -16, -14,
-12, -15, -16, -15, -15, -18, -18, -17, -13, -8, -5, -6, -8, -11, -9, -8, -9,
-10, -12, -13, -10, -9, -8, -4, -4, -4, -5, -3, 0, -1, -4, -5, -5, -6, -4, -1,
-1, };