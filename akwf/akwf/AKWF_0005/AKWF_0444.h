#define DATA_LENGTH 512
#define DATA AKWF_0444

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 7, 8, 9, 11, 12, 13, 14,
16, 17, 18, 19, 20, 22, 23, 23, 25, 26, 28, 28, 29, 31, 32, 33, 34, 35, 35, 37,
38, 39, 40, 40, 42, 42, 44, 45, 45, 46, 47, 48, 49, 49, 51, 51, 52, 53, 53, 55,
54, 56, 56, 57, 57, 59, 59, 60, 61, 61, 62, 63, 63, 64, 64, 65, 66, 66, 66, 67,
69, 69, 69, 70, 71, 72, 72, 72, 73, 74, 74, 75, 75, 75, 76, 76, 77, 78, 78, 79,
78, 79, 80, 81, 81, 81, 82, 82, 83, 83, 83, 84, 85, 85, 85, 86, 87, 86, 88, 88,
87, 88, 88, 89, 89, 89, 90, 90, 91, 91, 92, 92, 92, 92, 92, 94, 94, 94, 94, 94,
94, 95, 95, 95, 96, 96, 97, 97, 97, 98, 98, 98, 98, 99, 99, 99, 100, 100, 100,
100, 101, 100, 102, 101, 101, 102, 102, 102, 102, 103, 103, 103, 104, 104, 105,
105, 105, 105, 105, 105, 105, 106, 106, 107, 106, 107, 106, 107, 107, 107, 108,
109, 109, 109, 109, 109, 110, 109, 109, 109, 110, 111, 110, 110, 111, 111, 111,
112, 112, 112, 112, 113, 112, 112, 113, 113, 112, 113, 113, 113, 113, 114, 114,
114, 114, 115, 114, 115, 114, 116, 116, 116, 116, 116, 116, 115, 115, 117, 116,
116, 116, 117, 117, 117, 116, 117, 118, 117, 118, 117, 118, 118, 119, 117, 119,
118, 120, 118, 120, 98, 35, -3, -26, -41, -52, -60, -65, -70, -75, -81, -85,
-89, -93, -98, -100, -104, -106, -109, -109, -111, -112, -112, -114, -114, -114,
-114, -115, -115, -115, -115, -116, -115, -115, -114, -114, -115, -115, -115,
-114, -115, -114, -114, -114, -114, -114, -115, -113, -113, -113, -114, -113,
-114, -113, -113, -112, -113, -113, -112, -112, -111, -111, -111, -111, -111,
-110, -110, -111, -110, -109, -109, -109, -110, -109, -109, -109, -109, -108,
-108, -109, -108, -108, -108, -107, -106, -107, -106, -106, -106, -106, -106,
-106, -105, -105, -105, -105, -104, -104, -104, -103, -103, -103, -102, -103,
-102, -102, -102, -102, -100, -101, -100, -101, -100, -99, -100, -98, -99, -98,
-97, -98, -98, -98, -96, -96, -96, -96, -96, -96, -95, -95, -95, -94, -94, -94,
-94, -93, -92, -92, -92, -91, -91, -90, -90, -90, -90, -88, -88, -89, -88, -88,
-88, -86, -86, -85, -86, -86, -85, -85, -84, -84, -83, -83, -82, -83, -81, -81,
-80, -80, -79, -79, -78, -78, -78, -77, -77, -75, -76, -75, -75, -75, -74, -73,
-73, -72, -71, -71, -70, -69, -69, -69, -68, -67, -67, -67, -65, -64, -64, -64,
-63, -62, -61, -61, -59, -59, -59, -58, -58, -58, -56, -55, -55, -53, -52, -52,
-51, -50, -50, -49, -48, -48, -46, -46, -45, -44, -42, -42, -41, -40, -40, -38,
-38, -36, -36, -35, -33, -32, -32, -31, -29, -28, -27, -26, -24, -23, -22, -22,
-20, -19, -18, -17, -14, -14, -12, -11, -10, -8, -7, -5, -4, -3, -1, 0, };