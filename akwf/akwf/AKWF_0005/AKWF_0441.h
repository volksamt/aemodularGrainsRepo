#define DATA_LENGTH 512
#define DATA AKWF_0441

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 13, 18, 21, 25, 28, 31, 34, 37,
40, 41, 43, 45, 47, 49, 51, 52, 44, 34, 29, 29, 30, 31, 31, 32, 32, 34, 35, 36,
37, 38, 40, 40, 43, 47, 46, 49, 50, 53, 55, 57, 58, 60, 61, 63, 64, 64, 65, 66,
67, 67, 68, 68, 68, 68, 68, 68, 69, 69, 66, 55, 45, 40, 39, 40, 39, 39, 39, 39,
40, 40, 40, 41, 41, 42, 43, 44, 45, 46, 48, 49, 51, 53, 54, 56, 57, 57, 58, 57,
58, 59, 60, 60, 62, 62, 65, 65, 67, 68, 69, 71, 71, 67, 55, 48, 46, 47, 48, 48,
48, 48, 50, 51, 52, 52, 53, 55, 56, 57, 58, 60, 62, 63, 65, 67, 71, 72, 75, 76,
77, 79, 80, 82, 82, 84, 86, 87, 87, 89, 90, 90, 93, 93, 94, 94, 86, 75, 70, 69,
71, 71, 70, 71, 72, 72, 74, 78, 81, 84, 86, 87, 88, 90, 91, 92, 94, 95, 97, 98,
98, 100, 101, 101, 102, 103, 103, 103, 104, 105, 104, 105, 105, 105, 104, 105,
104, 104, 101, 89, 79, 75, 74, 75, 73, 72, 73, 72, 73, 73, 74, 74, 74, 74, 76,
76, 77, 77, 78, 81, 81, 84, 85, 86, 88, 88, 87, 88, 89, 89, 90, 91, 91, 92, 93,
94, 95, 95, 97, 98, 99, 93, 81, 74, 73, 73, 75, 74, 74, 74, 76, 73, 57, 48, 49,
42, 37, 31, 26, 22, 16, 11, 4, 1, -2, -7, -13, -16, -19, -23, -26, -28, -30,
-33, -35, -36, -39, -40, -40, -42, -43, -44, -44, -46, -56, -68, -73, -75, -74,
-76, -77, -77, -78, -77, -77, -76, -76, -76, -75, -74, -79, -83, -81, -81, -84,
-85, -85, -85, -86, -87, -87, -87, -87, -86, -86, -86, -86, -86, -86, -86, -87,
-86, -88, -87, -87, -88, -91, -104, -113, -118, -118, -118, -119, -119, -119,
-119, -118, -118, -114, -114, -113, -113, -110, -108, -107, -105, -104, -103,
-100, -98, -97, -95, -94, -93, -93, -93, -92, -91, -91, -89, -88, -88, -86, -85,
-84, -83, -81, -80, -78, -85, -98, -103, -104, -103, -103, -103, -103, -102,
-101, -100, -99, -98, -97, -96, -95, -93, -92, -91, -89, -88, -85, -82, -80,
-78, -75, -74, -73, -71, -70, -68, -67, -66, -65, -64, -62, -61, -61, -59, -58,
-57, -55, -56, -65, -76, -80, -80, -79, -80, -79, -79, -78, -77, -76, -74, -74,
-72, -71, -70, -70, -68, -67, -66, -65, -63, -62, -60, -59, -58, -58, -56, -56,
-55, -54, -53, -53, -53, -53, -53, -52, -52, -52, -52, -52, -51, -55, -68, -78,
-80, -81, -81, -82, -82, -81, -80, -80, -80, -80, -79, -79, -78, -77, -76, -75,
-73, -72, -71, -68, -68, -66, -64, -64, -63, -62, -61, -61, -60, -60, -58, -57,
-56, -55, -55, -53, -52, -50, -50, -49, -55, -67, -73, -73, -72, -72, -71, -71,
-69, -67, -66, -64, -62, -60, -56, -52, -48, -42, -37, -31, -25, -19, -13, -5,
0, };