#define DATA_LENGTH 512
#define DATA AKWF_0487

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 12, 16, 20, 21, 25, 27,
29, 32, 34, 35, 37, 38, 41, 41, 42, 42, 43, 43, 45, 44, 44, 43, 42, 42, 41, 40,
39, 37, 37, 34, 33, 32, 30, 28, 28, 26, 25, 23, 21, 21, 19, 19, 19, 18, 18, 17,
17, 17, 17, 18, 18, 18, 19, 19, 22, 23, 24, 26, 28, 28, 30, 33, 35, 37, 40, 41,
43, 47, 48, 51, 53, 55, 58, 58, 62, 56, 25, -10, -35, -54, -62, -63, -60, -57,
-55, -59, -66, -75, -84, -94, -99, -102, -101, -98, -94, -91, -87, -86, -86,
-85, -84, -81, -76, -71, -64, -57, -50, -42, -36, -30, -23, -19, -11, -5, 3, 10,
17, 23, 29, 35, 40, 45, 48, 52, 56, 59, 61, 64, 65, 67, 68, 67, 66, 65, 64, 62,
59, 57, 53, 51, 46, 43, 38, 34, 28, 24, 19, 14, 10, 5, 0, -3, -9, -12, -16, -21,
-24, -27, -29, -31, -33, -35, -36, -37, -38, -38, -37, -36, -36, -34, -31, -28,
-27, -23, -20, -17, -12, -9, -5, -1, 3, 8, 12, 17, 21, 25, 29, 33, 37, 41, 44,
48, 50, 53, 56, 57, 59, 62, 62, 63, 63, 64, 64, 63, 62, 61, 59, 58, 56, 54, 52,
50, 46, 44, 41, 37, 35, 31, 28, 26, 22, 18, 16, 12, 11, 9, 6, 3, 2, -1, -1, -3,
-5, -5, -5, -5, -5, -5, -4, -3, -2, -2, 1, 3, 3, 7, 8, 11, 14, 16, 19, 21, 25,
27, 30, 33, 35, 37, 41, 43, 46, 48, 50, 52, 52, 55, 56, 57, 58, 59, 59, 60, 59,
59, 58, 58, 57, 56, 55, 53, 52, 50, 49, 48, 45, 42, 41, 39, 37, 34, 33, 31, 28,
26, 25, 23, 22, 20, 19, 17, 16, 15, 15, 14, 13, 14, 13, 13, 13, 14, 15, 15, 16,
17, 18, 20, 21, 22, 25, 26, 28, 30, 32, 33, 35, 36, 38, 40, 42, 43, 46, 37, 5,
-28, -52, -70, -77, -79, -75, -73, -72, -76, -83, -93, -103, -111, -116, -120,
-118, -116, -112, -109, -107, -106, -107, -106, -104, -102, -99, -93, -87, -81,
-74, -68, -62, -57, -51, -45, -39, -33, -27, -20, -14, -8, -1, 3, 8, 13, 16, 19,
22, 25, 28, 29, 31, 32, 32, 32, 31, 29, 28, 26, 24, 21, 18, 15, 10, 6, 2, -3,
-7, -12, -16, -21, -25, -30, -35, -39, -44, -48, -52, -56, -58, -61, -64, -67,
-69, -70, -71, -72, -73, -73, -72, -71, -70, -69, -67, -65, -62, -59, -56, -53,
-49, -46, -41, -37, -34, -29, -25, -21, -17, -12, -9, -4, -1, 2, 6, 9, 12, 16,
17, 20, 21, 22, 24, 26, 25, 25, 25, 25, 25, 24, 22, 21, 20, 17, 15, 13, 11, 9,
6, 3, 0, -3, -5, -9, -11, -13, -17, -19, -22, -24, -25, -27, -29, -29, -31, -32,
-32, -34, -34, -33, -32, -31, -31, -30, -28, -27, -25, -22, -21, -19, -15, -14,
-10, -7, -4, -2, };