#define DATA_LENGTH 512
#define DATA AKWF_0413

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 10, 13, 16, 18, 21, 24, 28,
31, 37, 43, 45, 48, 50, 53, 53, 54, 54, 54, 54, 54, 55, 54, 55, 53, 54, 54, 53,
53, 52, 53, 52, 51, 51, 50, 49, 50, 49, 48, 48, 48, 47, 47, 46, 46, 46, 45, 45,
45, 45, 45, 43, 43, 44, 43, 43, 43, 43, 43, 43, 42, 42, 43, 43, 43, 43, 43, 43,
45, 45, 45, 45, 46, 47, 48, 48, 49, 51, 52, 52, 54, 56, 57, 57, 58, 61, 62, 64,
64, 67, 67, 69, 71, 73, 74, 76, 76, 78, 78, 81, 82, 83, 85, 85, 86, 87, 89, 89,
91, 92, 94, 93, 97, 94, 99, 96, 101, 98, 104, 100, 106, 102, 107, 104, 107, 110,
-36, -52, -38, -48, -39, -47, -40, -47, -41, -46, -42, -47, -44, -47, -44, -48,
-45, -48, -47, -48, -48, -49, -49, -50, -50, -50, -51, -51, -52, -51, -53, -52,
-53, -53, -54, -54, -55, -55, -55, -54, -55, -55, -53, -53, -53, -51, -50, -47,
-45, -40, -35, -30, -26, -23, -19, -17, -14, -13, -9, -6, -3, 2, 6, 9, 12, 13,
16, 19, 22, 26, 29, 33, 39, 43, 47, 49, 51, 51, 53, 54, 54, 54, 55, 55, 54, 54,
54, 54, 54, 53, 53, 52, 51, 52, 51, 50, 50, 50, 50, 49, 49, 49, 48, 48, 47, 46,
47, 46, 46, 45, 46, 44, 45, 44, 45, 43, 45, 42, 44, 42, 45, 41, 44, 41, 44, 40,
46, 38, -41, -44, -42, -44, -42, -43, -41, -44, -42, -44, -42, -44, -43, -45,
-44, -45, -44, -45, -44, -46, -46, -46, -46, -47, -47, -47, -48, -49, -49, -49,
-50, -50, -50, -51, -51, -52, -52, -53, -53, -53, -54, -54, -54, -54, -55, -54,
-55, -54, -55, -53, -52, -51, -51, -49, -47, -42, -37, -32, -28, -25, -22, -19,
-16, -13, -10, -8, -4, -1, 4, 7, 10, 13, 16, 17, 20, 24, 28, 31, 36, 41, 45, 48,
50, 52, 52, 54, 54, 54, 54, 55, 55, 54, 54, 54, 54, 54, 53, 53, 52, 52, 52, 51,
51, 50, 50, 49, 49, 48, 49, 48, 48, 47, 48, 45, 46, 44, 46, 44, 46, 43, 45, 43,
44, 43, 43, 44, 43, 42, -71, -116, -101, -109, -103, -107, -101, -104, -100,
-101, -98, -100, -97, -97, -95, -94, -93, -92, -90, -89, -89, -88, -87, -85,
-83, -82, -82, -80, -80, -77, -76, -74, -74, -72, -70, -69, -67, -66, -64, -63,
-62, -60, -59, -57, -57, -55, -53, -52, -51, -50, -49, -49, -48, -47, -45, -45,
-44, -45, -44, -43, -43, -43, -42, -43, -43, -42, -42, -42, -43, -43, -43, -43,
-44, -44, -43, -45, -44, -45, -45, -45, -46, -45, -46, -46, -47, -48, -48, -48,
-49, -49, -50, -50, -50, -51, -51, -52, -52, -52, -53, -53, -54, -54, -54, -54,
-55, -54, -54, -55, -54, -54, -54, -52, -53, -51, -48, -45, -41, -36, -31, -28,
-23, -20, -18, -15, -13, -9, -7, -3, };