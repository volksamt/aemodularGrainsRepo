#define DATA_LENGTH 512
#define DATA AKWF_0497

const PROGMEM int8_t DATA[DATA_LENGTH] = {-52, -62, -57, -61, -58, -61, -58,
-61, -59, -61, -59, -60, -59, -61, -58, -60, -59, -60, -59, -59, -59, -60, -59,
-60, -60, -59, -60, -60, -61, -59, -60, -59, -61, -59, -61, -58, -61, -57, -62,
-56, -65, -50, 0, 1, -3, 3, -4, 6, -19, -65, -58, -60, -59, -59, -60, -59, -60,
-59, -60, -59, -59, -60, -60, -60, -59, -60, -59, -60, -57, -63, -50, 2, -1, -1,
1, -2, 2, -4, 8, -37, -65, -56, -62, -58, -61, -59, -61, -59, -60, -59, -61,
-58, -62, -56, -66, -37, 7, -3, 3, -2, 0, -1, 0, 1, 0, 1, 1, 0, 0, 0, 0, 0, -1,
0, 0, 1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 1, 0, 0,
-1, 1, -1, 1, 0, 1, 0, 0, 1, -2, 4, -48, -64, -57, -61, -58, -60, -59, -60, -59,
-60, -60, -60, -59, -59, -59, -60, -60, -59, -60, -59, -60, -59, -60, -60, -59,
-59, -60, -59, -59, -59, -59, -61, -58, -61, -58, -62, -55, -66, -35, 7, -3, 1,
-1, 2, -2, 1, 0, 1, 0, 1, 0, 0, -1, 2, -1, 1, -1, 2, -3, 5, -13, -65, -57, -60,
-59, -59, -60, -59, -59, -59, -60, -59, -60, -60, -60, -59, -60, -59, -60, -59,
-60, -59, -59, -59, -60, -60, -60, -60, -59, -59, -59, -59, -59, -60, -60, -59,
-60, -60, -61, -59, -60, -59, -60, -59, -61, -57, -63, -54, -87, -127, -114,
-123, -115, -122, -116, -123, -115, -125, -105, -55, -62, -58, -61, -58, -60,
-58, -61, -57, -63, -56, -67, -33, 7, -4, 2, -2, 2, -1, 1, -1, 1, 0, 0, 0, 0,
-1, 0, -1, 0, 0, 1, -1, 0, -1, 0, 0, -1, 1, -1, 1, -3, 6, -44, -64, -56, -62,
-57, -60, -59, -61, -58, -61, -58, -60, -59, -60, -59, -60, -59, -59, -59, -60,
-59, -60, -60, -59, -59, -59, -60, -60, -59, -59, -59, -60, -60, -59, -60, -59,
-60, -58, -60, -59, -60, -59, -60, -58, -60, -58, -60, -58, -4, 2, -1, 1, -1, 1,
-1, 1, -1, 1, -1, 0, 0, 1, -1, 1, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, -1, 2, -1, 0, -1, 0, -1, 1, -2,
0, 0, -56, -62, -58, -60, -57, -60, -59, -61, -58, -60, -59, -59, -59, -59, -58,
-59, -59, -60, -59, -59, -60, -59, -60, -59, -59, -60, -60, -60, -60, -60, -59,
-60, -59, -60, -59, -59, -59, -60, -59, -60, -59, -60, -59, -60, -59, -60, -60,
-60, -60, -57, -64, -13, 5, -3, 2, -1, 2, -1, 1, 0, 0, 1, 0, 2, -2, 3, -7, 35,
68, 55, 64, 54, 67, 22, -7, 3, -2, 2, -1, 2, -2, 1, 0, 1, -1, 0, -1, 0, 0, 1, 0,
0, 0, 0, };