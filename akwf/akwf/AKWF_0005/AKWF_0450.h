#define DATA_LENGTH 512
#define DATA AKWF_0450

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 17, 25, 34, 41, 46, 52, 59, 63, 67,
71, 75, 78, 81, 83, 86, 88, 90, 92, 94, 95, 97, 98, 99, 100, 102, 102, 103, 105,
104, 105, 106, 107, 107, 108, 109, 109, 109, 110, 110, 110, 110, 111, 111, 112,
112, 112, 112, 113, 113, 113, 113, 113, 113, 114, 114, 115, 114, 115, 115, 115,
116, 115, 115, 116, 115, 116, 116, 116, 117, 116, 116, 116, 116, 116, 116, 117,
116, 117, 118, 117, 116, 117, 116, 118, 118, 117, 117, 118, 117, 117, 117, 117,
117, 118, 117, 118, 118, 117, 118, 118, 117, 118, 118, 118, 118, 118, 118, 119,
118, 119, 119, 118, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 118, 117,
115, 114, 113, 114, 113, 113, 114, 113, 113, 113, 113, 113, 112, 113, 112, 113,
111, 112, 112, 113, 112, 113, 112, 113, 112, 113, 112, 112, 112, 113, 113, 112,
113, 113, 112, 112, 113, 112, 112, 112, 113, 113, 114, 114, 113, 113, 113, 113,
113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 114, 114, 113,
114, 114, 113, 113, 114, 113, 113, 114, 113, 113, 113, 112, 113, 112, 113, 113,
113, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 110, 110, 110, 111,
110, 109, 108, 109, 109, 109, 107, 107, 107, 106, 105, 105, 105, 103, 103, 102,
101, 99, 99, 97, 97, 95, 94, 91, 90, 88, 86, 82, 80, 77, 58, 31, 8, -9, -21,
-30, -36, -43, -49, -54, -60, -65, -69, -75, -78, -82, -84, -87, -90, -91, -94,
-95, -97, -98, -99, -101, -101, -102, -104, -104, -104, -106, -106, -106, -108,
-107, -109, -108, -109, -110, -109, -110, -110, -110, -111, -111, -111, -111,
-112, -112, -111, -111, -112, -113, -113, -113, -112, -112, -112, -113, -113,
-113, -113, -112, -113, -113, -113, -113, -113, -112, -113, -114, -113, -113,
-114, -114, -113, -113, -113, -114, -113, -113, -114, -114, -113, -113, -113,
-113, -113, -113, -113, -114, -113, -113, -112, -113, -113, -113, -112, -113,
-113, -113, -112, -113, -112, -112, -112, -112, -113, -112, -112, -112, -112,
-112, -112, -112, -112, -112, -112, -112, -112, -112, -112, -112, -112, -111,
-111, -111, -113, -116, -117, -117, -118, -117, -118, -117, -118, -118, -117,
-117, -118, -118, -119, -119, -118, -119, -119, -119, -119, -118, -118, -118,
-118, -119, -119, -118, -119, -118, -119, -118, -118, -117, -118, -118, -118,
-118, -117, -117, -117, -118, -117, -118, -118, -118, -117, -118, -117, -117,
-117, -117, -117, -117, -116, -116, -117, -116, -116, -117, -116, -116, -116,
-116, -116, -116, -116, -115, -115, -115, -115, -115, -115, -115, -115, -114,
-114, -114, -114, -114, -114, -114, -114, -113, -113, -113, -113, -112, -113,
-112, -111, -112, -112, -111, -110, -110, -110, -109, -108, -108, -108, -107,
-107, -106, -105, -105, -105, -103, -103, -101, -101, -99, -99, -97, -95, -94,
-92, -91, -88, -85, -83, -80, -77, -73, -69, -64, -58, -52, -44, -35, -24, -11,
-2, };