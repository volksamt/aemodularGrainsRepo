#define DATA_LENGTH 512
#define DATA AKWF_0481

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 9, 12, 16, 22, 25, 30, 34, 38,
42, 45, 50, 54, 58, 60, 64, 68, 71, 74, 78, 81, 84, 87, 89, 92, 95, 97, 98, 100,
102, 104, 106, 106, 108, 108, 109, 110, 110, 109, 110, 110, 109, 108, 107, 107,
105, 104, 103, 101, 99, 97, 93, 91, 88, 86, 83, 80, 77, 74, 71, 67, 64, 60, 56,
53, 49, 45, 40, 36, 33, 28, 23, 19, 16, 11, 6, 1, -3, -8, -13, -16, -21, -26,
-31, -36, -40, -44, -50, -54, -58, -63, -67, -71, -75, -78, -82, -85, -89, -92,
-95, -98, -101, -103, -106, -109, -111, -112, -113, -115, -115, -117, -118,
-118, -118, -118, -119, -119, -118, -119, -117, -116, -115, -113, -111, -110,
-108, -106, -105, -101, -99, -96, -93, -90, -87, -84, -81, -77, -73, -70, -66,
-62, -59, -55, -50, -46, -42, -38, -33, -28, -24, -20, -17, -12, -7, -3, 1, 6,
10, 15, 19, 22, 26, 30, 34, 37, 41, 45, 49, 53, 55, 59, 62, 64, 68, 70, 73, 76,
78, 81, 82, 84, 86, 87, 89, 91, 92, 93, 94, 94, 96, 95, 96, 97, 95, 96, 96, 96,
96, 95, 94, 93, 93, 92, 91, 90, 89, 88, 86, 85, 84, 81, 80, 78, 76, 75, 72, 69,
68, 66, 63, 61, 58, 55, 53, 50, 47, 45, 41, 39, 35, 32, 30, 26, 22, 20, 16, 13,
10, 6, 4, 0, -3, -7, -10, -13, -15, -20, -23, -25, -29, -32, -35, -38, -41, -44,
-47, -50, -53, -55, -57, -60, -63, -65, -68, -69, -72, -75, -76, -78, -80, -81,
-82, -85, -87, -87, -88, -90, -90, -91, -92, -93, -93, -93, -93, -93, -94, -94,
-93, -93, -92, -93, -91, -90, -88, -89, -87, -85, -84, -82, -81, -80, -77, -75,
-74, -72, -68, -66, -64, -61, -59, -57, -53, -50, -47, -45, -42, -39, -35, -33,
-29, -26, -24, -20, -16, -13, -11, -8, -5, -1, 1, 4, 8, 10, 12, 16, 18, 20, 23,
26, 29, 31, 33, 35, 37, 39, 41, 43, 44, 46, 47, 49, 49, 50, 51, 53, 54, 54, 55,
56, 56, 57, 58, 58, 59, 59, 60, 60, 60, 61, 61, 61, 62, 61, 63, 62, 62, 62, 62,
63, 62, 62, 63, 62, 62, 62, 62, 61, 62, 61, 61, 60, 60, 59, 58, 58, 58, 56, 55,
55, 54, 54, 52, 51, 51, 49, 49, 47, 46, 44, 43, 42, 41, 39, 38, 37, 35, 33, 33,
31, 28, 26, 24, 23, 21, 19, 16, 14, 12, 10, 7, 5, 3, 0, -2, -5, -8, -10, -12,
-15, -18, -21, -23, -26, -29, -31, -34, -37, -39, -42, -45, -48, -49, -52, -53,
-56, -59, -61, -63, -64, -66, -68, -69, -72, -73, -74, -76, -77, -78, -80, -79,
-81, -82, -81, -82, -81, -82, -82, -82, -81, -81, -81, -80, -79, -78, -77, -74,
-73, -72, -70, -68, -66, -64, -62, -60, -57, -54, -52, -49, -46, -43, -40, -37,
-33, -29, -25, -22, -18, -15, -10, -8, -3, };