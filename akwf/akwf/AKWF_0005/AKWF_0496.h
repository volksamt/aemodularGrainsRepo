#define DATA_LENGTH 512
#define DATA AKWF_0496

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -1, 0, 1, 2, 2, 2, 1, 0, -1, -4,
-6, -7, -8, -11, -12, -13, -16, -17, -19, -18, -16, -13, -8, -4, -1, -1, 1, 1,
0, 0, 0, -1, -1, -2, -3, -3, -4, -4, -5, -5, -7, -7, -7, -8, -7, -7, -6, -4, -5,
-5, -4, -4, -4, -6, -6, -7, -7, -8, -8, -8, -9, -9, -9, -8, -9, -10, -10, -9,
-9, -9, -11, -15, -23, -37, -56, -88, -112, -118, -109, -87, -70, -54, -43, -33,
-25, -20, -14, -10, -7, -4, 0, 3, 4, 6, 8, 9, 10, 10, 11, 10, 9, 9, 9, 9, 9, 8,
9, 9, 9, 9, 10, 11, 11, 11, 11, 12, 12, 13, 12, 12, 13, 12, 12, 12, 11, 12, 12,
11, 11, 12, 14, 20, 25, 31, 34, 35, 29, 20, 10, -1, -8, -12, -16, -18, -20, -20,
-18, -15, -11, -5, 0, 5, 9, 13, 16, 19, 22, 24, 26, 29, 30, 32, 33, 33, 31, 26,
20, 12, 4, -1, -3, -1, 2, 8, 14, 23, 29, 33, 34, 31, 28, 23, 19, 16, 12, 9, 9,
7, 5, 5, 3, 1, -1, 0, 0, 2, 2, 2, -3, -12, -27, -49, -80, -104, -109, -95, -75,
-61, -48, -39, -32, -27, -21, -17, -13, -10, -6, -3, -1, 3, 6, 9, 11, 13, 14,
15, 16, 26, 42, 48, 43, 34, 26, 22, 20, 21, 24, 28, 33, 37, 42, 44, 43, 39, 35,
31, 26, 22, 18, 14, 12, 11, 10, 7, 6, 5, 5, 6, 7, 9, 11, 10, 9, 7, 3, 0, -3, -6,
-9, -10, -13, -15, -18, -22, -25, -24, -19, -13, -5, 2, 5, 7, 8, 7, 7, 6, 6, 4,
3, 2, 1, 0, -1, -1, -3, -3, -4, -6, -6, -6, -5, -5, -4, -3, -3, -3, -3, -3, -4,
-4, -5, -6, -7, -7, -9, -8, -8, -9, -9, -9, -11, -11, -11, -10, -8, -9, -12,
-17, -26, -40, -64, -98, -116, -118, -105, -82, -65, -50, -39, -31, -24, -18,
-13, -9, -5, -2, 1, 3, 5, 6, 7, 9, 9, 8, 9, 9, 9, 9, 8, 8, 8, 7, 9, 9, 9, 9, 9,
9, 10, 10, 10, 10, 10, 10, 10, 10, 10, 10, 9, 9, 9, 9, 8, 9, 9, 9, 10, 11, 14,
15, 17, 15, 13, 8, 5, 3, 0, -3, -3, -4, -5, -6, -5, -3, -1, 1, 4, 5, 7, 9, 10,
11, 10, 12, 12, 12, 12, 13, 13, 12, 11, 9, 8, 6, 5, 3, 3, 3, 5, 6, 8, 11, 14,
16, 19, 21, 22, 23, 24, 22, 22, 21, 23, 23, 24, 26, 24, 23, 21, 20, 23, 27, 28,
23, 11, -7, -35, -71, -88, -83, -71, -58, -47, -37, -32, -26, -22, -18, -16,
-12, -10, -6, -4, -1, 1, 4, 7, 10, 13, 14, 16, 17, 20, 34, 54, 63, 60, 50, 40,
35, 34, 35, 37, 37, 36, 34, 32, 31, 28, 24, 21, 18, 14, 11, 8, 7, 5, 3, 2, 1, 0,
};