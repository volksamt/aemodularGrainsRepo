#define DATA_LENGTH 512
#define DATA AKWF_0452

const PROGMEM int8_t DATA[DATA_LENGTH] = {-8, -45, -73, -93, -105, -112, -116,
-119, -120, -117, -113, -110, -107, -103, -100, -96, -94, -91, -88, -83, -79,
-73, -67, -61, -53, -45, -38, -31, -24, -18, -13, -8, -4, -1, 1, 4, 5, 6, 8, 9,
9, 10, 10, 10, 11, 11, 12, 12, 12, 12, 12, 13, 13, 13, 12, 13, 13, 13, 12, 13,
12, 13, 13, 13, 13, 14, 12, 13, 13, 13, 13, 13, 13, 14, 14, 13, 13, 12, 13, 13,
13, 13, 14, 13, 13, 13, 14, 14, 12, 13, 12, 13, 13, 13, 13, 12, 13, 13, 13, 14,
13, 13, 13, 13, 13, 13, 14, 14, 13, 13, 14, 14, 13, 13, 13, 13, 13, 13, 13, 13,
13, 13, 12, 12, 14, 12, 13, 13, 13, 13, 12, 13, 13, 14, 13, 13, 13, 14, 12, 13,
13, 14, 13, 13, 13, 13, 13, 13, 14, 13, 13, 12, 13, 13, 12, 13, 14, 13, 13, 13,
14, 13, 13, 12, 13, 13, 13, 13, 13, 12, 14, 13, 13, 13, 13, 13, 13, 13, 13, 13,
13, 13, 13, 13, 12, 13, 13, 13, 13, 13, 13, 13, 13, 12, 14, 13, 12, 13, 13, 13,
13, 14, 13, 13, 14, 12, 12, 13, 13, 13, 13, 13, 13, 14, 13, 13, 13, 14, 13, 13,
13, 13, 13, 13, 12, 13, 13, 12, 13, 13, 13, 13, 12, 13, 13, 13, 13, 13, 13, 13,
13, 13, 13, 12, 12, 13, 14, 13, 13, 12, 13, 12, 13, 13, 13, 13, 13, 14, 14, 13,
13, 12, 13, 13, 12, 12, 14, 13, 13, 13, 13, 13, 12, 13, 12, 13, 13, 13, 13, 13,
13, 13, 14, 13, 13, 13, 14, 13, 13, 13, 13, 12, 12, 13, 13, 13, 13, 13, 13, 13,
13, 12, 13, 13, 13, 12, 12, 14, 13, 12, 13, 13, 13, 13, 13, 13, 13, 13, 12, 12,
12, 13, 12, 12, 13, 13, 13, 14, 13, 12, 12, 13, 13, 13, 13, 13, 13, 13, 13, 13,
13, 12, 13, 12, 12, 13, 13, 13, 13, 13, 13, 13, 12, 13, 13, 13, 12, 13, 13, 13,
12, 13, 12, 12, 13, 13, 12, 13, 13, 13, 12, 13, 12, 13, 14, 13, 13, 12, 13, 13,
12, 13, 12, 13, 12, 13, 13, 13, 12, 13, 13, 13, 12, 13, 13, 13, 13, 12, 13, 13,
13, 13, 13, 13, 13, 13, 13, 13, 13, 13, 12, 13, 13, 13, 13, 12, 13, 13, 13, 12,
13, 12, 12, 13, 13, 12, 12, 12, 13, 13, 13, 13, 12, 12, 13, 13, 12, 13, 13, 13,
12, 13, 13, 12, 13, 13, 12, 12, 13, 12, 13, 12, 12, 13, 12, 13, 13, 13, 12, 13,
12, 13, 12, 12, 12, 13, 13, 12, 13, 13, 13, 13, 13, 12, 12, 13, 13, 12, 13, 13,
13, 12, 13, 12, 13, 12, 13, 12, 12, 13, 13, 12, 13, 12, 13, 12, 13, 13, 13, 13,
12, 12, 13, 12, 13, 13, 13, 13, 12, 12, 14, 11, };