#define DATA_LENGTH 512
#define DATA AKWF_0500

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 115, 122, 116, 121, 117,
121, 117, 120, 118, 120, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118,
118, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118, 119,
119, 119, 119, 119, 118, 118, 118, 119, 119, 119, 119, 118, 119, 118, 119, 118,
119, 118, 119, 119, 119, 119, 118, 118, 119, 119, 118, 118, 118, 118, 118, 118,
118, 118, 118, 118, 118, 118, 118, 119, 119, 118, 118, 118, 118, 118, 118, 119,
119, 118, 118, 118, 119, 118, 119, 118, 117, 118, 118, 119, 118, 118, 118, 118,
118, 118, 118, 118, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 117,
117, 117, 118, 118, 118, 118, 117, 118, 117, 118, 118, 118, 117, 118, 117, 117,
118, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117,
117, 117, 118, 116, 117, 116, 117, 117, 117, 116, 118, 117, 117, 117, 117, 118,
116, 118, 116, 118, 116, 118, 115, 118, 114, 120, 115, 119, 114, 119, 114, 118,
114, 119, 114, 118, 116, 116, 117, 115, 119, 113, 122, 110, 125, 107, 127, 104,
127, 100, 127, 96, 127, 84, 127, -23, 32, 127, -71, 102, -127, 64, -28, 46, 127,
119, 46, -126, -71, -101, -92, -52, 127, 101, 126, 111, 103, -128, 33, 16, -128,
119, 63, -96, -93, -86, -97, -85, -97, -84, -96, -85, -96, -86, -94, -87, -94,
-88, -92, -90, -91, -91, -90, -91, -90, -91, -89, -92, -89, -91, -90, -92, -90,
-91, -91, -92, -91, -91, -89, -91, -90, -91, -91, -91, -90, -91, -91, -91, -91,
-91, -91, -90, -91, -90, -91, -90, -90, -90, -91, -90, -91, -90, -90, -90, -91,
-91, -90, -90, -90, -90, -91, -90, -90, -90, -91, -90, -90, -89, -90, -90, -90,
-90, -91, -89, -90, -90, -89, -89, -90, -90, -90, -90, -90, -90, -90, -90, -90,
-90, -90, -90, -90, -90, -89, -91, -90, -90, -90, -90, -89, -89, -90, -90, -89,
-89, -89, -90, -90, -90, -90, -90, -90, -89, -89, -90, -89, -89, -89, -90, -90,
-89, -90, -89, -90, -89, -89, -90, -89, -89, -89, -90, -90, -89, -90, -89, -89,
-90, -90, -89, -89, -90, -89, -90, -89, -89, -88, -90, -89, -88, -90, -89, -89,
-89, -89, -89, -89, -89, -89, -89, -89, -89, -89, -89, -89, -89, -89, -89, -89,
-89, -89, -89, -89, -89, -88, -88, -89, -89, -88, -89, -88, -89, -89, -88, -90,
-89, -89, -88, -89, -89, -88, -88, -89, -89, -89, -88, -88, -89, -88, -89, -88,
-89, -88, -89, -88, -89, -88, -89, -88, -89, -88, -88, -89, -89, -87, -88, -89,
-89, -88, -89, -88, -89, -88, -88, -88, -88, -89, -87, -88, -88, -88, -87, -89,
-87, -89, -86, -91, -86, -90, -87, -90, -87, -90, -87, -89, -88, -89, -87, -88,
-88, -86, -90, -85, -92, -82, -94, -80, -97, -78, -100, -75, -103, -71, -108,
-64, -117, -37, 65, -102, -84, -92, 74, -52, };