#define DATA_LENGTH 512
#define DATA AKWF_0434

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 84, 90, 72, 56, 50, 51, 50, 47,
43, 37, 31, 23, 15, 7, 3, 0, 0, 1, 4, 7, 8, 10, 11, 13, 15, 16, 19, 20, 23, 23,
25, 27, 28, 30, 33, 34, 35, 37, 39, 40, 43, 43, 45, 46, 48, 50, 51, 53, 55, 56,
58, 59, 61, 61, 63, 65, 66, 68, 69, 71, 73, 73, 75, 76, 77, 78, 80, 82, 82, 84,
85, 87, 86, 89, 89, 91, 92, 92, 93, 95, 95, 96, 97, 98, 99, 100, 101, 102, 103,
104, 104, 106, 106, 107, 107, 109, 109, 109, 110, 111, 112, 113, 112, 113, 114,
114, 114, 114, 116, 116, 116, 116, 116, 118, 117, 118, 118, 118, 118, 119, 118,
119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 118, 118, 118, 118, 118, 118,
118, 117, 117, 117, 117, 117, 116, 115, 116, 115, 115, 113, 113, 112, 111, 112,
111, 110, 110, 110, 108, 108, 107, 106, 105, 105, 104, 103, 103, 102, 100, 100,
98, 99, 96, 95, 95, 94, 93, 92, 91, 90, 88, 87, 86, 85, 83, 82, 81, 80, 79, 78,
77, 75, 73, 73, 72, 70, 68, 67, 65, 64, 63, 61, 59, 58, 56, 56, 54, 52, 50, 50,
47, 46, 44, 43, 41, 39, 38, 35, 34, 34, 32, 30, 28, 25, 25, 23, 21, 19, 17, 15,
14, 12, 11, 8, 7, 5, 2, 1, 1, 2, 6, 11, 19, 28, 35, 41, 45, 49, 51, 54, 57, 62,
67, 74, 65, 22, -42, -86, -88, -70, -55, -51, -50, -50, -46, -42, -36, -30, -21,
-14, -7, -3, -1, 0, -2, -5, -6, -8, -10, -12, -14, -15, -16, -19, -20, -23, -24,
-25, -28, -29, -31, -33, -33, -36, -37, -39, -41, -43, -44, -46, -48, -49, -50,
-51, -54, -55, -56, -57, -59, -61, -62, -64, -66, -67, -68, -69, -71, -72, -74,
-75, -76, -78, -78, -80, -81, -82, -84, -85, -85, -87, -88, -89, -90, -92, -93,
-94, -94, -95, -97, -97, -98, -99, -100, -102, -102, -103, -103, -104, -105,
-105, -106, -108, -108, -108, -110, -110, -111, -111, -112, -112, -113, -113,
-113, -115, -115, -116, -116, -116, -116, -117, -117, -117, -118, -118, -119,
-118, -118, -119, -119, -118, -119, -118, -119, -119, -119, -119, -120, -119,
-118, -119, -118, -118, -118, -119, -118, -118, -118, -117, -116, -116, -115,
-116, -115, -114, -114, -113, -113, -112, -113, -111, -111, -111, -110, -109,
-109, -108, -108, -107, -106, -105, -103, -103, -102, -101, -100, -99, -98, -98,
-97, -95, -95, -93, -92, -91, -91, -89, -89, -87, -86, -85, -83, -82, -82, -80,
-79, -77, -76, -75, -74, -72, -71, -70, -69, -67, -65, -64, -62, -61, -59, -59,
-56, -55, -53, -52, -50, -48, -47, -45, -44, -42, -40, -39, -38, -35, -35, -32,
-30, -28, -27, -26, -24, -23, -21, -19, -18, -16, -14, -12, -10, -9, -7, -5, -3,
-2, 0, -2, -6, -13, -20, -29, -36, -42, -46, -49, -51, -54, -58, -62, -68, -75,
-62, -18, };