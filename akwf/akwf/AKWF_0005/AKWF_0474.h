#define DATA_LENGTH 512
#define DATA AKWF_0474

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 15, 20, 23, 27, 29, 32, 35,
37, 39, 43, 45, 46, 48, 49, 51, 52, 54, 55, 57, 58, 59, 60, 61, 62, 62, 63, 64,
64, 65, 66, 66, 66, 67, 68, 67, 69, 68, 69, 69, 70, 69, 71, 71, 71, 71, 72, 73,
72, 72, 73, 74, 75, 74, 75, 76, 77, 77, 78, 78, 79, 79, 81, 80, 82, 82, 83, 83,
83, 85, 84, 85, 85, 85, 87, 88, 88, 88, 89, 88, 89, 89, 89, 90, 90, 90, 90, 90,
89, 90, 89, 89, 90, 89, 89, 88, 87, 88, 87, 87, 86, 86, 85, 85, 84, 84, 83, 83,
82, 82, 80, 80, 79, 79, 79, 79, 78, 78, 78, 77, 77, 76, 74, 70, 66, 64, 61, 59,
56, 55, 54, 52, 51, 51, 49, 49, 48, 48, 47, 47, 46, 45, 44, 45, 45, 45, 45, 44,
45, 44, 44, 45, 45, 44, 44, 44, 44, 44, 44, 44, 44, 44, 44, 43, 44, 44, 43, 43,
44, 44, 43, 43, 43, 42, 42, 42, 42, 42, 42, 41, 41, 41, 41, 41, 40, 39, 40, 39,
39, 39, 38, 38, 38, 37, 36, 37, 37, 36, 35, 36, 35, 35, 35, 33, 33, 34, 34, 33,
33, 32, 32, 31, 32, 30, 31, 31, 31, 30, 30, 30, 30, 29, 28, 29, 28, 27, 28, 27,
26, 27, 26, 26, 26, 25, 25, 25, 26, 25, 24, 24, 24, 23, 23, 24, 24, 24, 26, 30,
32, 34, 35, 37, 38, 38, 36, 29, 24, 17, 13, 9, 6, 3, -1, -3, -6, -7, -8, -10,
-12, -13, -14, -14, -15, -15, -15, -16, -16, -17, -16, -17, -16, -17, -17, -18,
-17, -17, -16, -17, -16, -16, -16, -16, -16, -15, -15, -15, -14, -14, -14, -14,
-13, -14, -13, -14, -13, -12, -12, -12, -11, -11, -10, -10, -10, -10, -9, -9,
-8, -8, -8, -7, -7, -7, -6, -5, -6, -6, -5, -5, -4, -5, -4, -4, -4, -4, -3, -3,
-3, -3, -4, -4, -4, -4, -3, -3, -4, -4, -4, -4, -5, -5, -6, -6, -5, -6, -7, -7,
-7, -8, -9, -9, -9, -10, -10, -11, -11, -12, -13, -13, -15, -14, -16, -17, -18,
-18, -20, -20, -21, -23, -25, -30, -35, -37, -41, -43, -46, -48, -51, -53, -55,
-57, -58, -60, -62, -64, -65, -66, -69, -70, -72, -72, -74, -76, -78, -78, -80,
-81, -82, -83, -85, -87, -87, -89, -90, -91, -93, -94, -94, -95, -97, -98, -99,
-100, -102, -103, -103, -105, -105, -106, -107, -108, -109, -109, -111, -111,
-111, -112, -113, -114, -114, -115, -115, -115, -116, -117, -118, -117, -118,
-118, -118, -118, -119, -118, -119, -118, -119, -119, -119, -118, -119, -119,
-118, -118, -118, -117, -117, -117, -116, -116, -115, -115, -114, -113, -113,
-112, -112, -111, -110, -109, -108, -107, -106, -105, -104, -103, -103, -101,
-100, -98, -97, -96, -95, -94, -93, -91, -90, -88, -87, -85, -85, -83, -81, -76,
-66, -53, -42, -32, -24, -16, -9, -4, };