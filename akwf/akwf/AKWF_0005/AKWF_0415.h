#define DATA_LENGTH 512
#define DATA AKWF_0415

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 15, 19, 23, 27, 30, 34, 36, 39,
40, 42, 42, 43, 44, 43, 43, 42, 41, 39, 38, 37, 34, 33, 32, 31, 30, 28, 27, 27,
26, 24, 24, 23, 23, 21, 21, 22, 21, 20, 21, 21, 21, 21, 22, 21, 22, 23, 24, 24,
25, 26, 26, 27, 27, 29, 30, 31, 32, 33, 34, 35, 37, 38, 39, 41, 42, 44, 46, 48,
49, 52, 54, 56, 59, 61, 64, 66, 69, 72, 74, 76, 79, 83, 86, 89, 90, 92, 95, 97,
98, 99, 101, 103, 104, 104, 106, 106, 107, 106, 108, 107, 107, 106, 108, 106,
106, 105, 105, 104, 105, 103, 102, 101, 99, 100, 97, 97, 94, 94, 90, 92, 86, 91,
83, 89, 82, 71, -56, -83, -13, -53, -21, -35, -26, -27, -26, -24, -26, -22, -24,
-21, -24, -20, -23, -20, -23, -20, -22, -20, -23, -21, -23, -22, -23, -23, -24,
-25, -26, -28, -28, -30, -30, -31, -33, -34, -36, -38, -39, -41, -41, -43, -43,
-44, -43, -43, -42, -41, -39, -38, -35, -32, -28, -25, -21, -16, -11, -6, 0, 5,
11, 16, 20, 25, 28, 32, 34, 37, 40, 41, 43, 43, 44, 44, 43, 42, 41, 41, 39, 37,
35, 34, 33, 32, 31, 29, 29, 28, 26, 26, 24, 23, 23, 21, 22, 21, 22, 21, 21, 21,
22, 21, 22, 21, 22, 21, 24, 23, 25, 24, 26, 26, 27, 28, 28, 31, 30, 33, 32, 36,
34, 40, 35, 44, 30, 9, -86, -59, -28, -60, -25, -46, -28, -38, -30, -33, -29,
-28, -29, -26, -27, -24, -26, -22, -25, -22, -24, -21, -23, -20, -22, -21, -23,
-21, -22, -21, -22, -22, -22, -24, -24, -25, -25, -27, -27, -29, -30, -32, -33,
-34, -35, -37, -38, -39, -41, -42, -42, -44, -44, -44, -43, -41, -40, -38, -37,
-33, -30, -27, -23, -18, -14, -8, -3, 3, 8, 13, 19, 23, 26, 29, 34, 36, 38, 41,
43, 43, 44, 43, 43, 43, 42, 41, 39, 38, 36, 35, 34, 33, 31, 31, 28, 28, 27, 26,
23, 25, 22, 23, 21, 22, 21, 22, 21, 21, 21, 20, 21, 21, 23, 21, 23, 21, 25, 22,
28, 24, 29, 25, 32, 26, 35, 27, 33, -6, -47, -51, -100, -69, -95, -85, -92, -94,
-92, -98, -95, -102, -97, -103, -98, -105, -101, -106, -103, -107, -105, -107,
-106, -107, -107, -108, -107, -107, -107, -106, -106, -105, -105, -103, -102,
-100, -100, -98, -96, -94, -92, -89, -87, -84, -82, -79, -76, -73, -70, -68,
-64, -62, -60, -57, -55, -52, -51, -49, -47, -46, -43, -42, -41, -39, -37, -36,
-35, -33, -32, -31, -31, -29, -28, -27, -26, -26, -25, -25, -24, -23, -23, -22,
-21, -21, -21, -22, -21, -21, -22, -21, -21, -23, -22, -22, -24, -24, -24, -26,
-27, -29, -29, -30, -32, -33, -34, -37, -38, -38, -39, -40, -42, -43, -44, -43,
-44, -43, -41, -40, -37, -35, -32, -29, -25, -22, -16, -12, -6, -2, };