#define DATA_LENGTH 512
#define DATA AKWF_0467

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 14, 25, 35, 46, 55, 65, 74, 83, 90,
98, 104, 108, 114, 116, 117, 118, 119, 118, 117, 115, 112, 110, 106, 102, 97,
93, 88, 82, 77, 72, 67, 61, 56, 51, 46, 42, 36, 33, 29, 24, 20, 16, 11, 7, 4, 0,
-3, -7, -10, -11, -14, -16, -19, -20, -22, -24, -26, -27, -28, -29, -30, -30,
-31, -31, -31, -31, -31, -30, -31, -30, -29, -29, -27, -26, -24, -24, -21, -20,
-20, -18, -15, -13, -11, -10, -7, -6, -4, -1, 0, 3, 5, 6, 9, 10, 13, 14, 16, 18,
21, 22, 23, 25, 26, 27, 28, 29, 29, 29, 30, 30, 30, 30, 30, 28, 28, 26, 25, 24,
24, 22, 21, 18, 17, 15, 14, 12, 11, 8, 7, 5, 4, 1, 0, -2, -3, -6, -8, -9, -11,
-12, -14, -15, -16, -17, -18, -19, -20, -20, -22, -22, -23, -24, -23, -24, -24,
-24, -24, -24, -24, -25, -23, -23, -23, -22, -22, -22, -21, -20, -20, -20, -19,
-20, -21, -22, -21, -21, -19, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10,
-9, -7, -6, -5, -3, -2, 0, 1, 3, 4, 5, 5, 5, 6, 6, 6, 7, 7, 7, 6, 6, 6, 4, 4, 3,
2, 1, 0, -1, -3, -4, -4, -6, -7, -9, -10, -11, -13, -15, -16, -18, -19, -20,
-21, -23, -22, -23, -24, -24, -24, -24, -24, -23, -23, -21, -22, -21, -19, -18,
-17, -16, -14, -12, -10, -8, -6, -5, -3, -2, 0, 2, 3, 5, 6, 7, 9, 9, 11, 12, 12,
14, 13, 14, 15, 15, 15, 16, 16, 16, 15, 16, 16, 15, 15, 13, 14, 13, 13, 13, 11,
11, 10, 10, 8, 8, 8, 7, 6, 5, 4, 3, 2, -1, -3, -5, -6, -7, -7, -9, -8, -10, -10,
-10, -11, -11, -12, -11, -11, -10, -11, -10, -10, -8, -7, -7, -5, -4, -5, -3,
-3, -1, 0, 0, 1, 3, 3, 4, 5, 6, 6, 6, 6, 7, 8, 8, 8, 9, 9, 9, 10, 10, 10, 11,
11, 11, 12, 13, 12, 12, 12, 12, 11, 11, 10, 10, 9, 8, 7, 6, 5, 4, 3, 1, 0, -1,
-4, -5, -6, -9, -10, -11, -12, -14, -15, -17, -17, -19, -20, -20, -21, -21, -22,
-23, -22, -23, -23, -23, -23, -23, -22, -22, -22, -20, -19, -19, -18, -17, -17,
-15, -15, -14, -12, -12, -11, -10, -8, -8, -7, -6, -4, -4, -4, -2, -2, -1, 0, 1,
2, 2, 1, 1, 1, 1, 1, 2, 2, 2, 2, 4, 4, 4, 3, 4, 5, 5, 6, 5, 6, 8, 8, 8, 8, 9, 9,
10, 10, 10, 10, 10, 10, 9, 9, 9, 10, 8, 8, 7, 6, 5, 5, 3, 3, 2, 1, 0, -2, -2,
-3, -4, -5, -5, -7, -7, -9, -8, -11, -12, -15, -18, -23, -31, -40, -51, -62,
-72, -81, -88, -91, -93, -93, -93, -91, -90, -88, -84, -80, -74, -69, -61, -51,
-41, -30, -19, -7, };