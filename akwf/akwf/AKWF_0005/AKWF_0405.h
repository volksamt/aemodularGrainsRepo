#define DATA_LENGTH 512
#define DATA AKWF_0405

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 43, 54, 63, 68, 70, 68, 62, 52,
42, 29, 18, 4, -6, -15, -21, -26, -29, -30, -29, -28, -24, -22, -17, -13, -9,
-5, -3, -1, 2, 3, 4, 5, 3, 5, 4, 3, 2, 1, 1, 0, -1, -2, -1, -2, -1, -2, -2, -2,
-2, -1, 0, 0, -1, -1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, -1, 1, 0, 1, -1, 1, 0, 1,
0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, -1, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 1, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1,
0, 0, 0, 1, 0, 0, 1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 1, -1, 0,
0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, -56, -104, -63, -18, 1, 33,
-23, -54, -26, -4, 37, 46, 50, 46, 51, 55, 60, 62, 61, 55, 44, 32, 19, 5, -6,
-17, -25, -29, -33, -33, -33, -30, -28, -23, -19, -15, -12, -8, -5, -2, 0, 1, 3,
4, 4, 3, 3, 3, 2, 0, 0, 0, -1, -1, -1, -2, -2, -1, -1, -1, -2, -2, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
1, 0, 1, -1, 1, -1, -1, 0, 0, 0, 1, 1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, -1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, -1, 0,
0, 0, 1, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, -1, 1, 0,
1, 0, 1, -1, 1, -1, 0, 0, 0, 0, 0, 0, -1, 1, -3, 3, -83, -115, -91, -55, -2, };