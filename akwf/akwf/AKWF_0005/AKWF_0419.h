#define DATA_LENGTH 512
#define DATA AKWF_0419

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 16, 20, 23, 27, 29, 32, 35,
36, 38, 40, 42, 43, 43, 45, 45, 45, 46, 45, 45, 46, 44, 44, 43, 42, 40, 40, 37,
36, 34, 33, 30, 28, 26, 26, 24, 22, 20, 18, 17, 15, 14, 12, 12, 9, 9, 7, 6, 6,
5, 3, 3, 2, 2, 1, 1, 0, -1, -2, -2, -2, -3, -4, -4, -5, -6, -7, -6, -8, -9, -10,
-11, -12, -12, -14, -14, -15, -16, -16, -17, -18, -18, -17, -16, -15, -13, -11,
-8, -6, -2, 2, 7, 11, 16, 21, 27, 33, 38, 43, 49, 53, 57, 60, 62, 64, 66, 67,
67, 66, 64, 62, 59, 54, 49, 44, 39, 32, 27, 21, 16, 9, 4, -2, -7, -12, -16, -20,
-24, -27, -30, -31, -33, -33, -34, -33, -33, -32, -31, -29, -27, -24, -22, -20,
-17, -15, -11, -8, -6, -2, 0, 3, 5, 8, 10, 12, 14, 16, 18, 19, 21, 22, 23, 24,
25, 26, 26, 27, 28, 28, 29, 30, 30, 30, 31, 31, 32, 32, 33, 33, 34, 34, 35, 34,
34, 35, 35, 34, 33, 33, 32, 30, 29, 27, 26, 24, 23, 20, 18, 15, 13, 11, 9, 6, 3,
2, 0, -3, -5, -7, -9, -11, -12, -14, -16, -17, -18, -19, -21, -21, -23, -22,
-24, -31, -53, -75, -86, -99, -108, -114, -117, -120, -119, -116, -113, -108,
-102, -95, -88, -79, -70, -62, -52, -43, -34, -27, -18, -11, -4, 2, 9, 14, 17,
20, 23, 26, 28, 28, 27, 26, 25, 24, 22, 20, 18, 14, 11, 9, 5, 2, -1, -3, -5, -7,
-8, -8, -8, -7, -6, -4, -1, 2, 6, 10, 14, 20, 24, 29, 36, 40, 44, 48, 52, 56,
57, 59, 60, 60, 60, 59, 57, 53, 50, 46, 42, 37, 31, 26, 20, 14, 8, 3, -2, -6,
-11, -16, -19, -22, -25, -28, -29, -31, -31, -32, -31, -32, -31, -29, -26, -24,
-23, -22, -19, -16, -13, -11, -8, -5, -2, 0, 2, 5, 8, 9, 13, 15, 16, 18, 19, 21,
20, 12, -6, -19, -28, -37, -43, -49, -53, -55, -56, -56, -56, -53, -52, -49,
-44, -40, -36, -31, -27, -22, -18, -13, -9, -5, -1, 3, 6, 9, 11, 14, 15, 17, 17,
18, 18, 18, 17, 16, 14, 13, 11, 9, 7, 4, 2, -1, -3, -6, -8, -10, -12, -14, -16,
-17, -18, -18, -18, -17, -16, -13, -10, -7, -4, 0, 4, 10, 14, 20, 25, 32, 38,
43, 48, 53, 57, 59, 63, 64, 66, 65, 66, 64, 62, 59, 55, 51, 47, 41, 36, 30, 23,
18, 12, 6, 0, -5, -9, -14, -18, -22, -25, -28, -30, -31, -33, -33, -33, -32,
-32, -31, -30, -28, -24, -23, -20, -18, -15, -13, -9, -6, -4, -1, 1, 4, 7, 9,
10, 4, -6, -19, -35, -46, -59, -70, -78, -86, -92, -96, -99, -102, -101, -101,
-97, -94, -91, -86, -81, -74, -68, -63, -55, -49, -42, -34, -28, -22, -14, -9,
-3, };