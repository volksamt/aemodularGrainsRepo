#define DATA_LENGTH 512
#define DATA AKWF_0453

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 15, 24, 33, 40, 48, 55, 62, 68, 73,
79, 84, 87, 92, 95, 99, 102, 105, 106, 108, 109, 107, 101, 61, 7, -31, -52, -64,
-72, -74, -78, -79, -79, -80, -82, -83, -84, -86, -86, -86, -86, -85, -82, -79,
-75, -72, -66, -61, -55, -47, -40, -32, -24, -15, -8, 0, 10, 16, 23, 29, 35, 40,
46, 50, 54, 57, 61, 64, 68, 70, 73, 75, 77, 80, 82, 84, 86, 88, 89, 91, 92, 93,
95, 96, 97, 98, 100, 100, 101, 101, 103, 103, 105, 105, 105, 106, 106, 107, 107,
109, 108, 109, 110, 111, 110, 111, 111, 112, 112, 113, 113, 114, 113, 114, 115,
114, 114, 116, 115, 115, 116, 116, 116, 116, 117, 117, 117, 118, 118, 117, 117,
118, 117, 119, 117, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 118, 120, 119, 119, 118, 119, 119, 118, 119, 118, 118, 118, 118, 118, 117,
118, 117, 118, 117, 117, 118, 116, 117, 117, 116, 116, 116, 116, 116, 115, 116,
115, 114, 114, 114, 114, 114, 114, 113, 112, 112, 112, 110, 111, 110, 110, 109,
109, 108, 108, 108, 106, 106, 105, 104, 104, 103, 103, 102, 100, 100, 98, 97,
97, 95, 94, 94, 92, 90, 89, 87, 86, 84, 81, 79, 78, 75, 72, 69, 67, 64, 60, 56,
53, 48, 43, 38, 32, 27, 20, 12, 2, -7, -17, -25, -33, -42, -49, -57, -62, -69,
-74, -80, -84, -88, -93, -96, -99, -102, -105, -107, -108, -110, -108, -98, -55,
-2, 34, 54, 65, 72, 76, 78, 78, 79, 81, 82, 83, 86, 85, 86, 86, 86, 84, 82, 79,
75, 71, 66, 60, 54, 46, 39, 32, 23, 15, 6, -2, -11, -17, -24, -29, -36, -41,
-45, -50, -54, -57, -61, -65, -68, -71, -73, -75, -78, -80, -82, -84, -86, -87,
-89, -90, -93, -93, -95, -96, -97, -98, -99, -99, -100, -102, -103, -104, -104,
-105, -106, -106, -107, -107, -109, -109, -110, -109, -110, -110, -111, -111,
-111, -112, -113, -114, -114, -113, -114, -115, -115, -114, -115, -115, -115,
-116, -116, -116, -116, -116, -117, -117, -117, -117, -117, -118, -117, -118,
-118, -117, -117, -118, -118, -118, -119, -119, -118, -119, -119, -118, -119,
-119, -118, -119, -119, -120, -119, -120, -120, -119, -119, -120, -119, -119,
-119, -119, -120, -120, -119, -120, -118, -119, -118, -119, -118, -119, -119,
-119, -118, -118, -119, -118, -118, -118, -117, -117, -118, -117, -117, -117,
-117, -117, -117, -116, -116, -116, -116, -116, -115, -115, -115, -114, -114,
-113, -114, -113, -114, -113, -112, -112, -112, -111, -112, -111, -110, -110,
-109, -109, -108, -108, -107, -106, -106, -106, -104, -104, -104, -102, -101,
-101, -100, -99, -98, -96, -95, -94, -92, -92, -89, -89, -87, -85, -83, -81,
-80, -77, -75, -73, -69, -67, -63, -60, -56, -53, -48, -43, -38, -31, -25, -18,
-9, -2, };