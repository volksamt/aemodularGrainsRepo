#define DATA_LENGTH 512
#define DATA AKWF_0475

const PROGMEM int8_t DATA[DATA_LENGTH] = {36, 50, 52, 58, 59, 62, 59, 60, 57,
56, 52, 51, 47, 45, 42, 41, 39, 36, 34, 32, 31, 28, 28, 26, 26, 25, 24, 23, 23,
22, 24, 19, 13, 15, 15, 15, 15, 16, 16, 16, 16, 17, 18, 18, 19, 20, 20, 20, 21,
21, 21, 22, 22, 23, 23, 23, 23, 23, 23, 24, 24, 24, 23, 28, 33, 32, 33, 33, 34,
33, 33, 33, 33, 33, 33, 33, 34, 33, 32, 33, 33, 33, 33, 32, 33, 33, 33, 33, 33,
32, 33, 32, 33, 32, 33, 30, 22, 24, 22, 24, 24, 23, 23, 23, 23, 23, 23, 23, 23,
23, 24, 23, 23, 23, 23, 23, 23, 22, 24, 23, 24, 22, 23, 22, 23, 23, 23, 27, 32,
32, 32, 32, 31, 33, 30, 35, 29, 56, 75, 70, 73, 70, 73, 71, 72, 71, 72, 71, 71,
71, 71, 71, 71, 72, 72, 71, 71, 71, 73, 67, 61, 62, 62, 62, 63, 62, 62, 62, 63,
63, 63, 63, 62, 63, 63, 62, 62, 62, 63, 63, 62, 61, 63, 63, 62, 62, 62, 62, 62,
62, 62, 67, 72, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 72, 72, 71, 72,
70, 71, 71, 71, 71, 71, 71, 70, 71, 69, 86, 94, 91, 93, 88, 82, 84, 83, 83, 83,
82, 83, 84, 83, 82, 84, 82, 83, 83, 84, 82, 84, 81, 84, 81, 85, 81, 85, 80, 86,
80, 86, 79, 86, 78, 89, 78, -81, -87, -81, -87, -82, -87, -82, -87, -82, -86,
-82, -86, -82, -85, -82, -85, -83, -86, -83, -85, -84, -85, -84, -84, -84, -84,
-85, -84, -84, -84, -84, -87, -95, -92, -94, -91, -96, -82, -70, -73, -71, -71,
-71, -72, -71, -73, -72, -72, -73, -72, -72, -72, -72, -72, -72, -72, -72, -72,
-71, -71, -72, -72, -71, -67, -63, -63, -63, -63, -63, -62, -63, -62, -63, -62,
-62, -62, -63, -62, -63, -62, -62, -62, -62, -63, -63, -63, -62, -63, -62, -63,
-62, -64, -62, -64, -61, -67, -72, -71, -72, -71, -71, -72, -72, -71, -71, -71,
-72, -71, -71, -71, -72, -71, -72, -71, -72, -69, -74, -59, -29, -35, -31, -33,
-31, -32, -31, -31, -32, -26, -23, -23, -23, -22, -23, -22, -23, -22, -23, -22,
-23, -22, -23, -22, -22, -22, -22, -22, -22, -23, -22, -22, -23, -22, -22, -23,
-22, -23, -22, -23, -21, -28, -32, -30, -32, -32, -31, -31, -31, -31, -31, -31,
-31, -32, -31, -31, -32, -31, -31, -31, -30, -31, -31, -31, -32, -31, -31, -31,
-31, -31, -31, -31, -31, -26, -22, -22, -21, -22, -21, -22, -23, -22, -21, -23,
-22, -21, -22, -22, -22, -22, -21, -22, -22, -23, -21, -21, -22, -22, -22, -22,
-21, -23, -22, -23, -21, -27, -31, -31, -30, -31, -31, -31, -30, -32, -31, -31,
-31, -30, -32, -31, -31, -30, -30, -28, -31, -27, -32, -26, -33, -24, -34, -19,
-55, -119, -78, -61, -45, -27, };