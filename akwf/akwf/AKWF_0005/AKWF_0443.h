#define DATA_LENGTH 512
#define DATA AKWF_0443

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 19, 29, 24, -10, -17, -8, -14,
-17, -16, -13, -10, -5, -5, -3, -1, 0, 0, 0, 0, 1, 2, 2, 3, 4, 5, 6, 6, 7, 8, 7,
9, 8, 8, 9, 7, -3, -13, -16, -16, -15, -15, -15, -14, -10, -10, -7, -6, -3, -1,
2, 5, 16, 27, 30, 32, 35, 43, 49, 51, 54, 58, 60, 63, 65, 67, 68, 70, 70, 72,
72, 72, 72, 70, 69, 68, 66, 63, 56, 44, 33, 28, 28, 26, 25, 23, 22, 23, 22, 21,
20, 20, 20, 19, 19, 19, 19, 20, 21, 22, 22, 24, 26, 27, 26, 24, 22, 22, 21, 19,
20, 18, 19, 18, 19, 19, 20, 21, 22, 24, 24, 15, 4, -1, -1, 0, 0, 0, 1, 0, 0, 2,
2, 2, 2, 2, 3, 3, 5, 5, 6, 8, 10, 13, 17, 19, 19, 23, 24, 25, 27, 30, 31, 33,
34, 36, 39, 39, 42, 44, 45, 48, 51, 50, 42, 34, 33, 35, 38, 40, 41, 42, 45, 47,
49, 49, 51, 53, 55, 57, 58, 60, 61, 63, 64, 65, 66, 68, 69, 68, 67, 66, 65, 63,
61, 58, 57, 54, 52, 48, 45, 40, 37, 32, 29, 23, 14, -3, -13, -19, -22, -26, -27,
-30, -31, -32, -31, -34, -34, -35, -38, -36, -31, -30, -27, -26, -23, -20, -16,
-12, -8, -5, -2, -1, 1, 4, 7, 10, 12, 17, 21, 25, 29, 33, 37, 42, 47, 52, 55,
51, 41, 40, 42, 47, 48, 45, 47, 48, 50, 51, 51, 52, 52, 53, 53, 55, 56, 56, 57,
57, 58, 59, 60, 61, 61, 62, 61, 62, 63, 64, 64, 65, 67, 69, 71, 71, 74, 76, 78,
81, 83, 84, 76, 69, 68, 72, 75, 75, 67, 64, 69, 71, 70, 67, 65, 66, 66, 66, 65,
64, 63, 61, 59, 59, 57, 54, 52, 49, 47, 43, 39, 36, 31, 27, 23, 19, 15, 11, 6,
2, -4, -9, -15, -20, -31, -48, -59, -64, -68, -70, -73, -75, -76, -77, -78, -78,
-80, -79, -79, -79, -78, -77, -74, -73, -71, -68, -65, -62, -57, -54, -54, -53,
-52, -51, -49, -47, -46, -43, -41, -39, -37, -33, -31, -28, -26, -22, -21, -28,
-38, -41, -41, -38, -37, -36, -37, -35, -34, -35, -34, -35, -35, -35, -35, -36,
-37, -37, -38, -39, -39, -37, -37, -38, -38, -39, -42, -43, -45, -46, -47, -48,
-51, -53, -54, -55, -57, -59, -61, -62, -64, -67, -79, -88, -91, -92, -91, -91,
-92, -92, -92, -91, -75, -52, -37, -26, -18, -14, -11, -10, -9, -8, -6, -7, -7,
-7, -8, -8, -9, -12, -13, -16, -19, -22, -25, -28, -30, -33, -38, -42, -46, -50,
-55, -60, -70, -88, -99, -105, -107, -110, -113, -116, -115, -116, -117, -118,
-119, -114, -117, -119, -118, -116, -114, -112, -108, -106, -102, -99, -95, -92,
-89, -87, -86, -83, -80, -78, -74, -70, -65, -60, -56, -51, -45, -39, -32, -26,
-21, -25, -31, -29, -23, -16, -6, };