#define DATA_LENGTH 512
#define DATA AKWF_0417

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 3, 3, 4, 6, 6, 7, 8, 8, 9,
11, 12, 14, 15, 16, 18, 20, 22, 24, 28, 30, 32, 35, 37, 40, 44, 46, 49, 52, 54,
57, 59, 62, 64, 66, 68, 70, 72, 74, 75, 76, 79, 80, 81, 82, 83, 84, 85, 85, 86,
87, 87, 87, 87, 88, 88, 88, 88, 88, 89, 88, 88, 88, 89, 88, 88, 87, 87, 88, 88,
87, 86, 87, 87, 87, 85, 86, 85, 85, 85, 85, 85, 84, 84, 84, 83, 83, 83, 83, 83,
83, 84, 84, 84, 84, 84, 85, 85, 86, 86, 87, 87, 88, 88, 90, 90, 91, 91, 92, 92,
93, 93, 94, 95, 95, 96, 96, 98, 96, 97, 97, 97, 99, 99, 98, 97, 98, 97, 96, 96,
95, 95, 95, 94, 92, 92, 91, 90, 88, 87, 86, 84, 84, 82, 76, 68, 63, 56, 52, 46,
41, 36, 31, 25, 21, 17, 12, 8, 3, -1, -5, -10, -14, -18, -21, -25, -29, -33,
-36, -39, -44, -47, -51, -54, -56, -60, -62, -67, -69, -72, -74, -79, -81, -83,
-87, -89, -93, -95, -97, -99, -102, -105, -107, -108, -111, -112, -114, -116,
-116, -117, -119, -119, -119, -119, -119, -118, -117, -116, -115, -114, -112,
-110, -109, -106, -105, -102, -100, -99, -96, -93, -91, -89, -87, -84, -82, -80,
-77, -75, -73, -71, -69, -68, -65, -64, -62, -61, -59, -57, -56, -54, -51, -50,
-49, -47, -46, -43, -42, -41, -40, -37, -36, -35, -33, -31, -29, -29, -26, -25,
-24, -21, -19, -18, -17, -15, -13, -12, -9, -7, -6, -4, -1, -2, -3, -5, -6, -7,
-8, -10, -9, -11, -11, -12, -12, -13, -13, -14, -13, -14, -14, -15, -15, -15,
-14, -15, -15, -15, -15, -15, -15, -16, -15, -16, -15, -16, -16, -15, -14, -15,
-15, -15, -15, -15, -16, -16, -16, -16, -17, -17, -17, -18, -19, -19, -20, -21,
-20, -21, -21, -22, -22, -23, -22, -23, -23, -23, -21, -21, -20, -21, -19, -17,
-16, -14, -13, -11, -9, -7, -5, -2, 0, 3, 5, 8, 10, 12, 15, 17, 18, 21, 23, 24,
26, 28, 30, 31, 32, 33, 34, 36, 37, 38, 40, 41, 42, 42, 42, 43, 44, 44, 44, 45,
46, 46, 47, 47, 47, 48, 48, 48, 49, 49, 49, 49, 50, 50, 51, 51, 51, 51, 51, 51,
48, 46, 42, 37, 34, 30, 26, 22, 18, 14, 10, 6, 2, -2, -6, -10, -13, -17, -20,
-25, -28, -31, -36, -38, -41, -44, -48, -51, -55, -57, -60, -63, -65, -67, -70,
-72, -74, -76, -78, -80, -81, -83, -84, -85, -86, -86, -87, -87, -88, -88, -88,
-87, -88, -87, -86, -86, -86, -85, -83, -82, -81, -80, -79, -78, -77, -74, -73,
-70, -69, -67, -66, -64, -61, -60, -59, -56, -54, -52, -50, -49, -47, -45, -43,
-41, -38, -37, -35, -33, -30, -28, -27, -24, -22, -21, -20, -17, -16, -14, -13,
-11, -9, -9, -7, -5, -5, -3, -3, -1, 0, };