#define DATA_LENGTH 512
#define DATA AKWF_0433

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 5, 7, 6, 4, 4, 2, 1, 1, 1, 1, 3,
3, 4, 4, 6, 8, 10, 11, 12, 14, 15, 18, 18, 20, 22, 23, 24, 26, 27, 29, 30, 31,
33, 34, 36, 36, 37, 39, 40, 40, 41, 42, 43, 44, 45, 46, 46, 46, 46, 48, 48, 49,
49, 50, 49, 50, 50, 50, 50, 50, 51, 51, 51, 51, 51, 50, 50, 51, 51, 51, 50, 50,
50, 49, 49, 48, 48, 48, 48, 46, 47, 46, 45, 45, 44, 44, 43, 43, 42, 42, 42, 40,
40, 39, 39, 38, 37, 36, 36, 35, 34, 34, 33, 32, 31, 31, 30, 29, 29, 28, 27, 27,
26, 25, 24, 23, 22, 21, 21, 19, 19, 18, 17, 16, 15, 15, 14, 13, 12, 11, 11, 10,
9, 7, 7, 7, 5, 4, 3, 2, 2, 1, 0, -1, -1, -2, -3, -4, -6, -6, -6, -8, -9, -10,
-10, -11, -12, -13, -13, -13, -15, -15, -16, -17, -18, -19, -18, -20, -21, -21,
-21, -22, -22, -23, -24, -24, -24, -25, -25, -25, -26, -25, -26, -26, -26, -25,
-25, -24, -24, -22, -22, -19, -16, -14, -11, -9, -7, -8, -8, -10, -11, -13, -15,
-16, -18, -19, -21, -21, -22, -22, -18, -12, -2, 9, 22, 34, 43, 52, 57, 63, 68,
72, 79, 87, 94, 76, 18, -62, -113, -119, -103, -90, -86, -84, -79, -72, -63,
-53, -39, -26, -12, 0, 10, 15, 19, 19, 18, 17, 14, 13, 11, 8, 5, 1, -2, -4, -5,
-7, -6, -4, -3, -2, -1, 0, -1, -2, -3, -3, -3, -5, -6, -8, -9, -11, -13, -14,
-15, -17, -19, -20, -21, -23, -25, -27, -28, -30, -31, -31, -32, -34, -36, -37,
-37, -39, -39, -41, -41, -42, -43, -44, -44, -45, -46, -47, -47, -48, -48, -49,
-48, -49, -50, -49, -50, -51, -51, -50, -51, -50, -51, -50, -51, -50, -50, -50,
-51, -50, -50, -50, -49, -50, -49, -48, -47, -47, -47, -47, -47, -45, -46, -46,
-44, -44, -44, -43, -43, -41, -42, -41, -40, -39, -38, -37, -37, -36, -36, -35,
-35, -33, -34, -32, -31, -30, -30, -29, -29, -28, -27, -26, -26, -26, -24, -23,
-23, -22, -21, -20, -19, -19, -17, -17, -15, -15, -14, -12, -13, -12, -10, -10,
-9, -8, -7, -6, -6, -5, -3, -3, -2, -1, 1, 0, 2, 3, 4, 4, 5, 7, 7, 8, 9, 10, 10,
11, 11, 12, 13, 14, 15, 15, 16, 17, 18, 18, 19, 20, 21, 21, 22, 22, 23, 23, 23,
24, 24, 25, 25, 25, 25, 26, 25, 25, 25, 25, 24, 24, 23, 23, 20, 19, 17, 13, 11,
8, 8, 8, 8, 9, 10, 12, 15, 16, 18, 19, 20, 21, 22, 21, 18, 11, 1, -10, -23, -35,
-45, -52, -59, -62, -68, -74, -80, -89, -94, -72, -10, 69, 115, 118, 101, 89,
85, 84, 78, 71, 62, 52, 39, 25, 9, -2, -10, -15, -19, -19, -17, -16, -14, -12,
-10, -7, -4, -1, };