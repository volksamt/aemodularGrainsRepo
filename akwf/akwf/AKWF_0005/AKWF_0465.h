#define DATA_LENGTH 512
#define DATA AKWF_0465

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 15, 29, 43, 59, 73, 86, 98, 106,
113, 118, 119, 119, 117, 116, 112, 107, 102, 96, 90, 85, 76, 69, 61, 52, 44, 36,
27, 21, 15, 8, 3, -2, -7, -11, -14, -17, -20, -22, -24, -24, -25, -25, -25, -24,
-24, -24, -22, -22, -22, -20, -20, -19, -18, -18, -17, -15, -14, -12, -10, -9,
-9, -9, -10, -10, -11, -13, -13, -15, -16, -16, -17, -18, -18, -18, -17, -19,
-18, -19, -17, -16, -15, -13, -11, -10, -8, -7, -5, -2, -1, 1, 3, 5, 7, 8, 9,
11, 12, 14, 14, 15, 16, 17, 17, 17, 17, 17, 18, 17, 17, 16, 16, 16, 15, 14, 15,
16, 17, 18, 18, 18, 17, 15, 14, 11, 10, 8, 7, 5, 3, 2, 1, 0, -3, -4, -6, -6, -6,
-8, -9, -9, -9, -10, -10, -9, -10, -11, -10, -10, -9, -8, -6, -4, -3, -2, -1, 0,
-1, -1, -2, -4, -4, -5, -5, -7, -7, -8, -8, -8, -8, -10, -10, -9, -8, -7, -5,
-3, -2, -2, -2, -2, -3, -3, -3, -4, -3, -4, -4, -4, -4, -3, -3, -2, 0, 1, 2, 3,
3, 3, 3, 2, 1, 1, 1, 2, 3, 4, 5, 4, 4, 4, 2, 0, -1, -2, -1, 0, 1, 0, 0, 0, -1,
-2, -3, -3, -3, -2, -2, -2, -2, -4, -4, -4, -3, -4, -3, -4, -3, -3, -3, -2, -1,
-1, -2, -3, -1, -2, -2, -1, -1, -1, 0, -2, -2, -4, -6, -7, -9, -9, -9, -9, -8,
-9, -8, -8, -7, -8, -9, -10, -12, -13, -14, -14, -14, -13, -12, -9, -9, -10, -9,
-9, -11, -11, -10, -9, -7, -6, -4, -4, -3, -3, -4, -3, -5, -5, -7, -6, -6, -5,
-3, -1, 1, 1, 1, 1, 0, -1, -1, -2, -3, -3, -3, -2, -2, 0, 1, 3, 3, 3, 3, 2, 2,
0, -1, 0, -1, -1, -2, -3, -4, -4, -4, -5, -6, -6, -5, -6, -6, -4, -3, -1, 1, 3,
4, 4, 4, 4, 3, 2, 1, 0, 1, -1, -1, -1, -2, -2, -3, -4, -5, -5, -6, -6, -6, -7,
-6, -6, -6, -6, -5, -5, -4, -3, -3, -1, 1, 4, 5, 5, 7, 7, 7, 6, 6, 5, 3, 2, 3,
2, 2, 0, 0, -1, -2, -3, -4, -4, -4, -4, -5, -4, -4, -4, -4, -3, -3, -3, -2, -1,
-2, -1, -1, 1, 1, 2, 2, 2, 2, 3, 2, 3, 3, 3, 4, 4, 3, 4, 3, 4, 4, 5, 6, 7, 10,
11, 11, 11, 11, 9, 9, 8, 7, 6, 5, 4, 2, 2, 1, 0, -1, -1, -3, -3, -4, -4, -5, -4,
-4, -4, -3, -2, -3, -2, -2, -2, -2, 0, 0, 0, 1, 1, 2, 3, 2, 3, 3, 3, 4, 3, 4, 4,
4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 2, 0, -8, -18, -34, -52, -72, -90, -104, -113,
-115, -112, -105, -93, -82, -68, -55, -41, -26, -10, };