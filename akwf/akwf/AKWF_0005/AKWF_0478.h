#define DATA_LENGTH 512
#define DATA AKWF_0478

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 31, 47, 64, 78, 91, 102, 110, 114,
118, 119, 118, 115, 108, 101, 91, 80, 69, 57, 43, 31, 19, 5, -7, -18, -29, -40,
-49, -58, -66, -73, -80, -86, -90, -93, -96, -98, -98, -97, -94, -91, -88, -85,
-80, -75, -71, -65, -59, -54, -50, -44, -40, -35, -29, -24, -19, -15, -9, -5, 0,
3, 8, 9, 11, 13, 13, 13, 13, 12, 10, 7, 5, 2, 0, -1, -1, -2, -1, 1, 4, 7, 12,
18, 24, 32, 39, 45, 53, 59, 65, 70, 73, 77, 78, 79, 80, 79, 77, 76, 73, 69, 66,
63, 59, 55, 51, 47, 43, 39, 36, 32, 29, 25, 22, 18, 15, 10, 6, 1, -5, -11, -19,
-25, -33, -39, -43, -47, -49, -49, -48, -46, -42, -38, -34, -28, -24, -19, -15,
-11, -8, -5, -2, 0, 1, 3, 3, 3, 3, 2, 0, -2, -5, -8, -12, -15, -20, -23, -29,
-34, -40, -45, -50, -54, -59, -63, -65, -67, -67, -66, -63, -60, -57, -52, -47,
-41, -34, -29, -23, -16, -10, -5, 2, 8, 13, 17, 22, 27, 30, 34, 37, 40, 42, 44,
44, 45, 44, 42, 40, 37, 33, 30, 25, 21, 18, 14, 10, 7, 4, 1, 1, 0, 1, 2, 3, 5,
8, 10, 14, 18, 21, 23, 27, 30, 33, 34, 36, 38, 39, 39, 38, 38, 37, 35, 32, 30,
27, 23, 18, 14, 10, 5, -1, -7, -13, -21, -27, -34, -42, -48, -53, -56, -59, -58,
-57, -53, -47, -40, -32, -23, -15, -6, 2, 9, 16, 21, 25, 28, 30, 30, 29, 28, 24,
21, 16, 12, 8, 4, -1, -6, -10, -14, -17, -21, -24, -27, -31, -34, -37, -38, -40,
-41, -43, -42, -41, -40, -37, -34, -31, -28, -23, -19, -15, -12, -9, -5, -2, 1,
3, 6, 8, 10, 13, 16, 17, 19, 22, 23, 26, 27, 28, 29, 30, 30, 29, 26, 26, 24, 20,
18, 15, 12, 9, 7, 5, 4, 3, 3, 3, 4, 6, 7, 10, 13, 16, 18, 21, 23, 25, 25, 26,
27, 27, 28, 27, 26, 24, 23, 20, 18, 16, 14, 11, 9, 7, 5, 2, -1, -3, -6, -8, -11,
-13, -15, -17, -21, -24, -28, -31, -35, -39, -41, -42, -43, -42, -40, -38, -34,
-30, -25, -20, -15, -12, -8, -4, -1, 1, 4, 5, 6, 7, 8, 9, 10, 10, 9, 9, 8, 7, 7,
5, 3, 2, 0, -3, -4, -7, -10, -13, -15, -17, -20, -21, -22, -22, -22, -21, -19,
-17, -14, -11, -9, -5, -1, 1, 4, 6, 10, 12, 14, 17, 19, 21, 24, 26, 27, 28, 29,
30, 30, 29, 29, 28, 27, 24, 22, 18, 14, 12, 8, 5, 2, -2, -5, -7, -9, -10, -11,
-11, -10, -9, -8, -7, -6, -3, -2, 2, 3, 5, 7, 8, 10, 11, 12, 14, 13, 13, 13, 12,
11, 7, 4, -1, -7, -13, -19, -26, -32, -38, -44, -50, -54, -59, -61, -65, -65,
-62, -57, -51, -41, -29, -15, -1, };