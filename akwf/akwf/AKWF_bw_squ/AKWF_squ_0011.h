#define DATA_LENGTH 512
#define DATA AKWF_squ_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 116, 122, 116, 122, 117,
122, 118, 120, 118, 121, 118, 119, 118, 120, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 120, 118, 120, 119, 120, 118, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 120, 120, 119, 119,
119, 119, 119, 120, 119, 120, 120, 119, 119, 120, 120, 119, 119, 119, 119, 119,
120, 118, 119, 119, 119, 118, 120, 118, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 117, 120, 118, 121, 117, 121, 117, 122, 116, 121, 116, 121,
117, 121, 117, 121, 118, 118, 125, -90, -128, -110, -126, -113, -124, -114,
-123, -115, -122, -117, -121, -117, -120, -117, -120, -118, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120,
-118, -120, -119, -119, -118, -120, -118, -119, -119, -120, -119, -120, -119,
-120, -119, -120, -119, -120, -119, -119, -119, -119, -120, -119, -120, -119,
-119, -118, -120, -118, -121, -117, -122, -116, -123, -114, -123, -114, -125,
-112, -127, -109, -128, -88, 127, 116, 119, 120, 118, 121, 116, 122, 116, 121,
116, 122, 117, 122, 117, 122, 118, 120, 117, 120, 118, 120, 119, 119, 119, 119,
118, 119, 119, 118, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 118, 119, 118, 119, 118, 119, 119, 119, 118, 119, 119, 120, 118, 119,
119, 120, 120, 119, 120, 117, 120, 118, 121, 117, 121, 117, 122, 116, 122, 115,
123, 115, 124, 115, 124, 113, 127, 104, -115, -122, -116, -123, -115, -123,
-115, -122, -116, -123, -116, -122, -118, -121, -117, -121, -117, -121, -117,
-120, -119, -119, -120, -119, -119, -119, -120, -119, -120, -119, -120, -118,
-120, -119, -119, -118, -119, -118, -119, -120, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -120, -119, -118, -120, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118, -118,
-119, -119, -119, -119, -120, -119, -119, -119, -118, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -120, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -118, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -118,
-119, -119, -120, -120, -119, -120, -119, -119, -119, -119, -120, -119, -120,
-119, -119, -119, -120, -119, -118, -119, -119, -119, -118, -119, -120, -119,
-119, -119, -119, -119, -120, -120, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -118, -119, -119, -120, -118, -119,
-118, -120, -117, -121, -117, -121, -117, -121, -116, -122, -114, -126, -101, };