#define DATA_LENGTH 512
#define DATA AKWF_squ_0091

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 3, 3, 3, 5, 5, 6, 6, 7, 8, 9,
10, 10, 11, 11, 13, 13, 14, 15, 15, 16, 17, 18, 18, 19, 20, 20, 21, 22, 22, 23,
23, 24, 25, 26, 26, 27, 28, 28, 29, 30, 31, 31, 32, 32, 33, 34, 35, 36, 36, 37,
38, 38, 39, 39, 41, 41, 42, 42, 43, 44, 44, 46, 46, 46, 47, 48, 49, 49, 50, 50,
51, 52, 53, 53, 54, 55, 56, 57, 57, 58, 59, 59, 60, 61, 61, 62, 63, 63, 64, 66,
65, 66, 67, 67, 69, 69, 69, 71, 71, 72, 73, 74, 74, 74, 75, 76, 77, 77, 78, 79,
79, 80, 81, 82, 82, 83, 84, 84, 85, 86, 87, 87, 87, 89, 89, 90, 90, 91, 93, 93,
93, 94, 94, 95, 97, 97, 97, 99, 98, 100, 101, 102, 102, 102, 103, 104, 105, 106,
106, 106, 107, 108, 109, 110, 110, 111, 112, 112, 113, 114, 114, 115, 116, 117,
116, 117, 118, 119, 119, 118, 118, 119, 118, 118, 119, 119, 119, 120, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
120, 119, 118, 119, 120, 119, 118, 119, 119, 119, 119, 119, 118, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 118, 119, 118,
119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
118, 120, 119, 121, 117, 121, 115, 127, 7, -124, -116, -121, -118, -121, -119,
-119, -119, -120, -120, -119, -119, -118, -119, -119, -119, -119, -119, -118,
-120, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -120, -119, -118, -119, -119, -119, -119,
-120, -119, -118, -120, -120, -118, -119, -119, -119, -120, -120, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -120, -119, -119,
-118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -118, -119, -120, -120, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -120, -119, -119, -120, -120, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -120, -120, -119,
-119, -119, -120, -119, -119, -119, -119, -120, -120, -119, -119, -120, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120,
-119, -119, -119, -118, -119, -119, -120, -119, -120, -119, -119, -119, -119,
-118, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118, -119,
-117, -120, -118, -120, -117, -120, -118, -121, -117, -121, -117, -121, -117,
-122, -115, -5, };