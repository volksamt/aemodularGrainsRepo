#define DATA_LENGTH 512
#define DATA AKWF_squ_0062

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 82, 119, 117, 120, 118, 120, 118,
119, 118, 119, 118, 119, 119, 120, 119, 120, 119, 120, 119, 118, 118, 119, 119,
118, 120, 119, 119, 118, 120, 117, 117, 38, -13, -4, -11, -7, -9, -7, -8, -8,
-9, -7, -9, -7, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -7, -8, -8, -8, -8, -8,
-7, -9, -8, -9, -7, -8, -9, -7, -7, -8, -8, -8, -7, -8, -8, -7, -8, -8, -8, -8,
-8, -9, -8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -8, -8, -9, -8, -7, -8, -8, -9,
-7, -8, -8, -9, -8, -8, -7, -8, -8, -9, -8, -8, -8, -8, -8, -7, -8, -8, -8, -8,
-8, -8, -7, -8, -8, -8, -9, -7, -8, -8, -8, -8, -8, -8, -8, -9, -8, -8, -8, -8,
-8, -8, -8, -7, -9, -8, -8, -8, -8, -8, -8, -8, -8, -7, -8, -8, -8, -8, -8, -8,
-8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -8, -7, -8, -8, -8, -8, -8, -7, -7, -8,
-7, -8, -8, -8, -8, -8, -8, -8, -9, -8, -8, -8, -7, -8, -8, -7, -8, -8, -8, -7,
-7, -8, -8, -7, -8, -8, -8, -8, -8, -8, -8, -7, -8, -8, -7, -9, -8, -7, -7, -9,
-8, -8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -8, -8, -8, -7, -7, -7, -7, -8, -8,
-8, -7, -8, -7, -8, -7, -7, -8, -8, -8, -8, -7, -8, -8, -7, -8, -8, -8, -8, -8,
-8, -8, -7, -8, -8, -8, -8, -8, -7, -8, -8, -8, -7, -8, -8, -7, -8, -7, -8, -7,
-8, -7, -8, -7, -8, -8, -8, -8, -8, -7, -8, -7, -7, -8, -8, -7, -7, -8, -7, -8,
-7, -8, -7, -8, -8, -8, -7, -8, -8, -8, -8, -7, -8, -8, -8, -8, -9, -8, -7, -8,
-7, -8, -8, -8, -7, -7, -8, -8, -8, -8, -8, -7, -8, -7, -7, -7, -8, -8, -8, -8,
-8, -7, -8, -8, -8, -8, -8, -8, -7, -8, -8, -8, -8, -7, -8, -7, -7, -8, -7, -7,
-8, -8, -7, -8, -7, -7, -7, -8, -7, -7, -7, -8, -8, -7, -8, -8, -7, -8, -7, -8,
-8, -8, -7, -8, -7, -8, -8, -7, -8, -7, -7, -7, -7, -8, -8, -8, -8, -8, -7, -8,
-7, -8, -8, -7, -8, -8, -8, -7, -8, -8, -7, -8, -7, -8, -7, -7, -8, -8, -7, -8,
-7, -7, -8, -7, -8, -8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -8, -7, -8, -7, -7,
-8, -7, -7, -7, -8, -8, -7, -7, -8, -8, -8, -8, -7, -8, -7, -8, -7, -7, -8, -8,
-8, -8, -8, -7, -8, -8, -8, -7, -8, -7, -7, -7, -8, -8, -8, -8, -8, -7, -7, -8,
-8, -7, -7, -8, -8, -8, -7, -8, -8, -8, -7, -8, -7, -8, -7, -8, -8, -8, -7, -7,
-7, -7, -7, -7, -8, -8, -7, -9, -7, -8, -7, };