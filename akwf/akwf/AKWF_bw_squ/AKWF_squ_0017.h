#define DATA_LENGTH 512
#define DATA AKWF_squ_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 2, 2, 4, 4, 5, 4, 6, 6, 6,
7, 6, 8, 8, 9, 8, 9, 10, 10, 10, 11, 12, 12, 13, 13, 14, 14, 15, 15, 15, 16, 16,
16, 17, 17, 18, 19, 20, 20, 20, 21, 21, 22, 21, 23, 22, 23, 24, 24, 24, 26, 26,
26, 27, 27, 27, 28, 28, 29, 29, 29, 30, 31, 30, 32, 33, 33, 33, 33, 33, 34, 36,
36, 35, 36, 37, 38, 37, 38, 38, 38, 40, 41, 40, 40, 41, 42, 42, 43, 43, 43, 44,
45, 45, 45, 47, 46, 47, 48, 48, 49, 48, 49, 50, 51, 50, 51, 51, 52, 52, 53, 54,
55, 55, 55, 56, 56, 57, 57, 58, 57, 58, 59, 59, 59, 60, 60, 61, 62, 62, 62, 63,
63, 64, 64, 65, 65, 65, 66, 67, 66, 68, 68, 68, 69, 69, 70, 70, 71, 71, 72, 72,
72, 73, 73, 74, 74, 74, 75, 77, 77, 77, 77, 78, 79, 79, 79, 79, 80, 81, 81, 81,
83, 83, 83, 84, 84, 84, 84, 84, 86, 86, 86, 87, 88, 88, 89, 89, 90, 90, 90, 91,
92, 91, 92, 93, 93, 93, 94, 95, 94, 95, 96, 97, 97, 98, 97, 98, 98, 99, 100, 99,
100, 100, 101, 101, 102, 103, 103, 103, 103, 104, 105, 105, 107, 107, 107, 107,
109, 107, 109, 109, 109, 110, 111, 111, 112, 111, 113, 113, 114, 113, 114, 116,
115, 116, 116, 118, 116, 120, 115, 126, 7, -124, -116, -121, -118, -120, -118,
-120, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -118,
-119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -118, -118, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -120, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -120, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-120, -120, -119, -119, -119, -118, -118, -119, -119, -120, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -120, -118, -118, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -118, -119,
-118, -120, -119, -119, -119, -119, -119, -118, -120, -119, -120, -118, -120,
-118, -120, -118, -121, -117, -121, -118, -121, -117, -122, -117, -121, -116,
-122, -115, -4, };