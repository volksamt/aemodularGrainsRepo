#define DATA_LENGTH 512
#define DATA AKWF_squ_0085

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 3, 6, 6, 6, 7, 9, 9, 11, 12,
13, 14, 15, 17, 16, 18, 18, 21, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 31,
33, 34, 35, 35, 37, 38, 38, 39, 41, 42, 43, 44, 45, 46, 47, 47, 49, 50, 51, 52,
53, 53, 54, 56, 58, 58, 58, 59, 60, 62, 63, 63, 64, 65, 67, 69, 68, 69, 70, 72,
72, 74, 75, 75, 76, 77, 79, 79, 81, 82, 83, 83, 85, 85, 86, 87, 88, 90, 90, 91,
93, 93, 94, 95, 97, 98, 99, 99, 100, 101, 102, 104, 104, 105, 106, 107, 109,
110, 111, 112, 112, 113, 115, 116, 116, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 120, 119, 119, 119, 120, 119,
119, 118, 119, 119, 120, 120, 120, 119, 119, 119, 119, 119, 120, 118, 119, 119,
119, 119, 118, 119, 120, 119, 120, 118, 119, 118, 119, 119, 119, 119, 120, 119,
120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 120, 119,
119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 118,
120, 118, 119, 118, 119, 119, 119, 120, 119, 119, 119, 120, 118, 120, 117, 122,
115, 126, 8, -124, -116, -121, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -119, -118, -119, -119, -120, -118, -119, -118, -120,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119,
-119, -120, -119, -120, -118, -118, -119, -119, -120, -119, -119, -119, -118,
-118, -118, -119, -120, -119, -119, -120, -119, -119, -118, -119, -119, -119,
-119, -118, -119, -119, -119, -118, -119, -118, -120, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -120, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -120, -119, -120, -119, -119, -119,
-120, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -118,
-120, -119, -119, -118, -119, -119, -119, -120, -119, -118, -119, -119, -119,
-119, -119, -119, -120, -119, -120, -119, -119, -118, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-118, -119, -119, -119, -119, -118, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -120, -119, -120, -118, -121, -118,
-121, -117, -120, -117, -120, -118, -121, -117, -122, -115, -4, };