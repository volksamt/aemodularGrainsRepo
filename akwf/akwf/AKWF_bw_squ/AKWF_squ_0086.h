#define DATA_LENGTH 512
#define DATA AKWF_squ_0086

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 4, 5, 6, 6, 7, 8, 9, 10, 10,
12, 13, 13, 15, 16, 17, 17, 18, 20, 20, 21, 22, 23, 24, 25, 26, 28, 27, 29, 30,
31, 32, 33, 33, 35, 35, 36, 37, 38, 39, 40, 41, 42, 43, 43, 44, 45, 47, 48, 49,
49, 50, 51, 52, 53, 54, 55, 56, 56, 57, 58, 60, 60, 62, 62, 63, 65, 65, 65, 67,
68, 69, 70, 71, 72, 72, 74, 74, 75, 77, 77, 78, 79, 80, 81, 82, 83, 84, 84, 85,
87, 87, 89, 89, 90, 91, 92, 93, 94, 96, 96, 97, 97, 99, 99, 100, 102, 103, 103,
104, 105, 107, 107, 107, 109, 110, 111, 111, 112, 114, 115, 115, 116, 117, 118,
119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 120,
120, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 120, 118, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119,
119, 120, 120, 119, 118, 119, 119, 118, 118, 119, 119, 119, 119, 118, 119, 119,
120, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 118,
119, 120, 119, 119, 119, 118, 120, 118, 120, 118, 120, 119, 119, 119, 119, 119,
119, 119, 119, 118, 120, 119, 118, 119, 119, 120, 118, 120, 118, 122, 116, 127,
7, -123, -116, -121, -118, -120, -118, -119, -119, -120, -119, -119, -119, -119,
-120, -118, -119, -118, -120, -119, -119, -119, -119, -118, -120, -118, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -120,
-119, -119, -120, -119, -120, -119, -119, -120, -118, -119, -120, -119, -118,
-119, -119, -118, -119, -118, -119, -119, -120, -118, -119, -119, -119, -119,
-119, -120, -120, -119, -119, -119, -120, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -120, -119,
-119, -119, -120, -118, -120, -120, -120, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119,
-119, -120, -119, -119, -118, -120, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -118, -119, -118, -120, -117, -120, -118, -120, -118, -121, -118,
-121, -117, -121, -116, -120, -117, -122, -115, -5, };