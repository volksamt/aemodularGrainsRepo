#define DATA_LENGTH 512
#define DATA AKWF_squ_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 27, 81, 115, 118, 116, 116, 114,
115, 114, 113, 112, 111, 111, 111, 110, 109, 109, 107, 107, 105, 80, 24, -11,
-14, -14, -14, -14, -14, -13, -13, -13, -12, -13, -13, -13, -12, -12, -12, -12,
-12, -12, -12, -12, -12, -12, -12, -12, -11, -12, -11, -12, -11, -11, -11, -12,
-11, -12, -11, -11, -10, -11, -10, -12, -11, -11, -11, -11, -11, -11, -11, -10,
-10, -10, -11, -11, -10, -10, -10, -10, -10, -10, -10, -10, -10, -10, -9, -10,
-10, -10, -9, -10, -10, -9, -10, -10, -9, -9, -9, -9, -8, -9, -9, -9, -9, -8,
-9, -9, -8, -8, -9, -8, -8, -9, -8, -8, -8, -8, -9, -9, -8, -9, -7, -8, -8, -8,
-8, -8, -7, -8, -8, -8, -8, -8, -8, -8, -7, -8, -8, -7, -8, -7, -7, -7, -7, -7,
-7, -7, -7, -6, -7, -7, -7, -7, -7, -6, -6, -7, -6, -7, -6, -7, -6, -7, -6, -7,
-6, -7, -7, -6, -6, -7, -6, -6, -7, -6, -6, -6, -6, -6, -6, -5, -5, -6, -6, -5,
-6, -6, -6, -5, -5, -5, -6, -6, -5, -6, -6, -6, -6, -5, -5, -5, -6, -6, -6, -5,
-6, -6, -5, -5, -5, -4, -5, -4, -5, -5, -5, -5, -5, -6, -5, -5, -5, -5, -5, -4,
-5, -4, -4, -5, -4, -4, -4, -4, -4, -4, -5, -4, -4, -4, -4, -4, -4, -5, -4, -4,
-3, -4, -4, -4, -4, -5, -3, -3, -4, -3, -3, -4, -4, -3, -4, -4, -3, -4, -4, -3,
-3, -3, -4, -3, -4, -3, -4, -3, -3, -3, -3, -3, -4, -4, -4, -4, -4, -4, -4, -3,
-3, -3, -2, -3, -3, -3, -4, -3, -3, -3, -3, -2, -3, -3, -3, -3, -2, -3, -2, -3,
-3, -3, -2, -3, -2, -2, -3, -3, -3, -3, -3, -2, -3, -2, -2, -2, -3, -2, -2, -2,
-3, -2, -2, -3, -2, -3, -2, -2, -2, -2, -2, -3, -3, -2, -2, -2, -2, -2, -2, -2,
-2, -1, -2, -2, -3, -2, -3, -2, -2, -2, -3, -2, -2, -1, -2, -2, -2, -2, -1, -2,
-1, -1, -2, -2, -2, -1, -1, -1, -2, -1, -2, -2, -1, -1, -2, -2, -1, -1, -2, -1,
-2, -2, -2, -1, -1, -1, -2, -1, -1, -2, -1, -1, -1, -1, -2, -1, -1, 0, -1, 0,
-1, 0, -1, -1, -2, -1, -2, -1, -2, -1, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1,
-1, -1, 0, 0, -1, -1, 0, -1, -1, -1, 0, 0, -1, 0, -2, -1, 0, -1, 0, -1, -1, -1,
-1, 0, -1, -1, 0, 0, 0, 0, -1, -1, 0, -1, -1, 0, -1, -1, 0, -1, -1, -1, -1, -1,
0, 0, -1, 0, 0, -1, -1, 0, -1, -1, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0,
-1, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, -1, };