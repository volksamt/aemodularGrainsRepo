#define DATA_LENGTH 512
#define DATA AKWF_squ_0099

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 1, 3, 4, 3, 4, 5, 5, 6, 7,
7, 7, 8, 9, 8, 10, 10, 10, 10, 12, 11, 12, 13, 13, 14, 15, 16, 15, 16, 17, 18,
18, 18, 18, 19, 19, 20, 20, 20, 22, 21, 23, 23, 23, 24, 24, 25, 25, 26, 26, 27,
28, 27, 29, 29, 29, 29, 31, 30, 31, 31, 33, 33, 33, 33, 34, 35, 35, 36, 36, 37,
37, 37, 38, 39, 39, 40, 40, 41, 41, 41, 43, 43, 43, 44, 44, 45, 46, 45, 46, 47,
47, 48, 48, 49, 49, 50, 50, 51, 51, 51, 53, 52, 54, 54, 54, 55, 55, 56, 56, 58,
57, 57, 58, 59, 58, 60, 60, 61, 61, 62, 63, 62, 63, 64, 64, 64, 65, 66, 66, 66,
67, 69, 68, 68, 69, 70, 70, 70, 72, 71, 72, 72, 73, 73, 75, 75, 76, 76, 77, 76,
77, 78, 78, 78, 79, 80, 80, 81, 81, 82, 83, 83, 84, 85, 84, 84, 85, 86, 86, 87,
87, 88, 88, 89, 89, 89, 90, 91, 91, 91, 92, 92, 94, 93, 95, 94, 95, 96, 96, 96,
97, 98, 98, 99, 99, 100, 101, 100, 101, 101, 102, 103, 103, 104, 105, 105, 105,
105, 106, 107, 108, 108, 109, 109, 109, 110, 110, 111, 111, 112, 112, 112, 114,
114, 114, 114, 116, 116, 115, 117, 117, 117, 117, 119, 119, 119, 119, 119, 119,
119, 119, 118, 120, 118, 120, 118, 120, 118, 122, 115, 126, 7, -124, -116, -121,
-117, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -118, -120,
-119, -120, -118, -119, -118, -119, -119, -119, -119, -119, -120, -120, -120,
-119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-118, -119, -119, -119, -120, -119, -120, -119, -119, -120, -119, -118, -119,
-119, -119, -119, -119, -120, -118, -120, -119, -118, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -120, -119, -120, -120, -120, -119, -119, -119, -118, -120, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -118, -120, -119, -120, -119, -119,
-119, -119, -118, -120, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -118, -119, -119, -118, -119, -119, -118, -119, -118,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119,
-120, -119, -118, -119, -119, -118, -119, -118, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -120, -119, -120, -119, -119, -119, -119,
-119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -118, -120, -118, -121, -118, -121, -117, -121, -117, -121,
-117, -122, -117, -121, -115, -5, };