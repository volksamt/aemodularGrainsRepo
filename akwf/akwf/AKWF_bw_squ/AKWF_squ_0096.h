#define DATA_LENGTH 512
#define DATA AKWF_squ_0096

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 2, 4, 3, 4, 5, 6, 6, 7, 7,
8, 8, 9, 9, 9, 11, 11, 12, 12, 13, 14, 15, 14, 15, 15, 17, 17, 17, 17, 18, 19,
19, 21, 21, 21, 22, 22, 22, 24, 24, 24, 25, 26, 26, 26, 28, 28, 29, 28, 29, 31,
30, 31, 32, 32, 33, 33, 34, 35, 35, 36, 36, 37, 37, 37, 39, 39, 40, 41, 41, 41,
42, 43, 42, 43, 44, 45, 45, 46, 46, 46, 47, 47, 49, 49, 49, 50, 50, 51, 51, 53,
53, 53, 54, 55, 56, 56, 56, 57, 57, 58, 58, 60, 60, 60, 61, 61, 61, 62, 63, 63,
65, 65, 65, 66, 66, 67, 67, 68, 68, 69, 70, 70, 70, 72, 72, 72, 73, 74, 75, 75,
76, 75, 77, 77, 77, 78, 79, 79, 80, 80, 82, 81, 82, 82, 84, 84, 85, 84, 86, 86,
87, 88, 88, 88, 89, 89, 90, 90, 91, 91, 93, 92, 94, 94, 94, 95, 95, 96, 96, 97,
98, 98, 98, 99, 99, 100, 100, 102, 101, 104, 103, 104, 104, 105, 105, 106, 107,
107, 108, 108, 108, 110, 109, 111, 111, 112, 112, 112, 113, 114, 114, 115, 116,
116, 117, 117, 118, 119, 119, 120, 119, 118, 120, 119, 119, 119, 120, 119, 119,
119, 118, 119, 118, 119, 118, 119, 118, 119, 119, 119, 119, 119, 118, 120, 118,
119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 118, 121, 117, 121, 115, 127,
7, -124, -116, -122, -118, -120, -118, -119, -118, -119, -119, -118, -120, -119,
-119, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -120, -119, -119, -119, -119, -120, -120, -120, -118, -119,
-119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -120, -119, -118, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120,
-120, -120, -119, -119, -119, -119, -119, -118, -119, -119, -118, -120, -119,
-119, -120, -119, -119, -119, -119, -118, -119, -118, -119, -120, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-118, -119, -120, -118, -119, -120, -120, -119, -119, -119, -120, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119,
-120, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -120, -118,
-119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -119, -119,
-119, -120, -118, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -120, -118, -119,
-119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -118, -119, -118,
-119, -119, -119, -119, -119, -119, -118, -121, -118, -121, -118, -120, -117,
-121, -116, -122, -116, -121, -117, -121, -115, -5, };