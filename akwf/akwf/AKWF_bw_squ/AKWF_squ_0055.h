#define DATA_LENGTH 512
#define DATA AKWF_squ_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 2, 1, 2, 2, 2, 2, 2, 3, 3,
4, 4, 3, 4, 4, 5, 4, 5, 5, 5, 6, 5, 7, 7, 6, 7, 7, 7, 8, 8, 7, 8, 8, 8, 8, 8, 9,
9, 9, 9, 9, 9, 9, 9, 10, 10, 10, 11, 10, 10, 10, 11, 12, 11, 11, 12, 11, 11, 12,
11, 12, 13, 12, 13, 13, 63, 97, 95, 100, 99, 102, 102, 104, 105, 106, 106, 107,
108, 109, 110, 110, 111, 111, 111, 112, 112, 112, 112, 113, 113, 112, 113, 113,
113, 112, 113, 113, 113, 112, 112, 112, 112, 111, 111, 111, 110, 110, 109, 109,
109, 108, 107, 107, 106, 105, 105, 104, 103, 103, 103, 103, 102, 100, 99, 99,
99, 98, 97, 96, 96, 95, 94, 93, 93, 92, 91, 90, 89, 89, 89, 86, 86, 86, 84, 83,
83, 82, 81, 80, 79, 78, 78, 77, 76, 75, 75, 74, 73, 72, 71, 71, 69, 69, 67, 67,
67, 65, 66, 64, 63, 63, 61, 61, 60, 59, 58, 57, 57, 56, 55, 54, 53, 52, 52, 51,
50, 49, 49, 49, 47, 46, 46, 45, 44, 44, 43, 42, 42, 40, 40, 39, 39, 38, 37, 36,
36, 35, 34, 34, 33, 33, 32, 31, 30, 30, 29, 28, 27, 27, 26, 26, 26, 25, 24, 23,
22, 22, 21, 21, 20, 20, 20, 18, 18, 18, 17, 16, 16, 16, 15, 14, 13, 13, 12, 13,
12, 12, 11, 10, 9, 10, 9, 8, 7, 7, 7, 6, 6, 6, 5, 5, 4, 4, 4, 3, 2, 1, 2, 1, 2,
0, 0, -1, -1, -1, -1, -2, -2, -3, -4, -3, -3, -4, -7, -23, -63, -98, -106, -108,
-109, -110, -111, -112, -114, -114, -115, -115, -117, -116, -118, -118, -118,
-119, -118, -119, -119, -118, -119, -119, -119, -119, -118, -118, -119, -118,
-117, -117, -117, -117, -116, -117, -116, -115, -114, -114, -113, -112, -112,
-112, -111, -111, -110, -109, -108, -107, -107, -106, -106, -104, -103, -103,
-102, -101, -100, -99, -98, -98, -97, -97, -94, -94, -95, -93, -92, -92, -90,
-89, -89, -88, -87, -86, -85, -85, -84, -82, -82, -81, -80, -79, -78, -77, -77,
-75, -74, -74, -73, -72, -71, -70, -70, -69, -68, -68, -66, -65, -65, -64, -63,
-62, -61, -60, -60, -59, -58, -58, -56, -56, -55, -54, -54, -53, -52, -51, -51,
-50, -49, -49, -48, -47, -47, -46, -45, -45, -44, -43, -42, -41, -41, -40, -39,
-38, -39, -38, -36, -37, -36, -35, -34, -34, -34, -33, -32, -32, -31, -30, -30,
-30, -29, -28, -27, -27, -27, -25, -25, -25, -24, -24, -23, -23, -23, -22, -21,
-21, -20, -20, -20, -20, -18, -18, -18, -16, -16, -17, -16, -16, -15, -15, -14,
-14, -14, -13, -12, -12, -12, -12, -11, -11, -10, -10, -9, -10, -8, -8, -8, -7,
-8, -7, -7, -6, -6, -5, -4, -5, -4, -5, -4, -4, -3, -3, -3, -2, -3, -2, -2, -1,
-1, 0, 0, 0, };