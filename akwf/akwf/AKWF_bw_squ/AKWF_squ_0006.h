#define DATA_LENGTH 512
#define DATA AKWF_squ_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 15, 25, 34, 41, 48, 54, 60, 64, 69,
72, 75, 79, 82, 84, 86, 88, 89, 91, 92, 93, 94, 95, 96, 97, 98, 98, 99, 99, 100,
99, 100, 102, 102, 102, 103, 103, 102, 104, 103, 103, 104, 105, 104, 104, 105,
106, 106, 105, 105, 106, 106, 105, 106, 107, 106, 107, 107, 108, 107, 107, 107,
108, 108, 108, 108, 109, 108, 108, 109, 109, 109, 109, 110, 109, 109, 110, 110,
110, 111, 110, 110, 110, 111, 111, 111, 111, 111, 111, 112, 111, 111, 112, 111,
112, 112, 112, 112, 111, 112, 112, 113, 113, 113, 113, 112, 113, 113, 113, 113,
113, 113, 113, 113, 114, 114, 113, 113, 113, 114, 114, 113, 114, 114, 114, 114,
115, 114, 115, 115, 115, 115, 114, 115, 115, 114, 114, 115, 114, 115, 115, 115,
115, 116, 115, 115, 115, 116, 116, 115, 115, 116, 115, 116, 116, 116, 115, 116,
116, 116, 116, 116, 116, 117, 116, 116, 116, 116, 117, 117, 117, 117, 117, 117,
117, 117, 117, 117, 117, 117, 116, 117, 117, 117, 118, 117, 117, 118, 117, 117,
117, 118, 117, 117, 117, 118, 118, 117, 118, 118, 118, 119, 118, 118, 119, 118,
118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 118, 118, 118,
118, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119,
118, 119, 119, 119, 119, 118, 120, 118, 119, 118, 117, 97, 58, 39, 21, 6, -10,
-24, -37, -48, -58, -67, -74, -80, -87, -91, -95, -99, -103, -104, -107, -109,
-110, -111, -112, -113, -114, -116, -116, -116, -116, -117, -117, -116, -117,
-117, -119, -118, -117, -118, -119, -118, -118, -118, -119, -118, -118, -118,
-118, -118, -118, -119, -118, -118, -118, -118, -118, -119, -118, -118, -118,
-118, -118, -117, -118, -118, -117, -118, -118, -117, -117, -118, -118, -117,
-117, -117, -117, -118, -118, -117, -117, -117, -117, -117, -117, -117, -117,
-117, -118, -117, -117, -117, -116, -116, -117, -116, -117, -116, -116, -116,
-117, -116, -117, -116, -116, -116, -116, -116, -116, -116, -116, -115, -116,
-116, -116, -115, -115, -116, -116, -115, -115, -116, -116, -116, -116, -115,
-115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -113, -114, -114,
-114, -114, -114, -114, -114, -113, -113, -113, -113, -114, -113, -114, -113,
-113, -113, -113, -113, -114, -113, -113, -113, -112, -113, -113, -113, -111,
-112, -112, -112, -112, -112, -112, -112, -111, -111, -111, -111, -111, -111,
-111, -111, -111, -110, -110, -110, -111, -110, -109, -110, -110, -110, -110,
-110, -109, -110, -109, -109, -109, -109, -109, -109, -109, -108, -107, -108,
-107, -108, -107, -108, -107, -107, -106, -106, -106, -106, -106, -105, -106,
-106, -105, -105, -105, -105, -104, -104, -104, -103, -103, -103, -103, -102,
-102, -102, -102, -101, -100, -100, -101, -100, -100, -100, -99, -99, -98, -98,
-97, -96, -95, -96, -94, -94, -92, -88, -84, -79, -73, -67, -60, -53, -46, -37,
-29, -20, -11, -3, };