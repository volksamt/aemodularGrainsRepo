#define DATA_LENGTH 512
#define DATA AKWF_squ_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {51, 116, 118, 120, 119, 120, 119, 120,
119, 119, 119, 119, 120, 118, 120, 120, 119, 118, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119,
119, 118, 119, 119, 118, 119, 120, 118, 118, 118, 119, 119, 118, 118, 119, 118,
119, 119, 118, 119, 118, 118, 118, 119, 118, 119, 118, 118, 118, 118, 118, 118,
118, 118, 118, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 117, 117, 118,
119, 118, 118, 118, 117, 118, 119, 118, 118, 117, 118, 118, 118, 118, 118, 118,
118, 118, 118, 118, 117, 118, 118, 117, 118, 118, 117, 118, 118, 118, 118, 118,
117, 117, 118, 117, 117, 118, 118, 118, 117, 117, 117, 117, 118, 117, 118, 117,
117, 118, 118, 117, 117, 117, 117, 116, 118, 117, 117, 117, 117, 116, 116, 117,
118, 118, 117, 118, 115, 118, 116, 119, 115, 120, 114, 121, 36, -62, -53, -59,
-55, -57, -56, -58, -57, -57, -57, -56, -57, -56, -57, -57, -57, -56, -58, -57,
-57, -56, -57, -57, -57, -56, -57, -56, -57, -56, -56, -57, -57, -57, -56, -57,
-56, -57, -57, -57, -57, -56, -57, -57, -57, -58, -57, -56, -57, -56, -57, -57,
-58, -57, -56, -57, -57, -57, -57, -57, -57, -57, -56, -57, -57, -57, -56, -57,
-56, -56, -57, -57, -57, -57, -57, -56, -56, -57, -57, -56, -56, -57, -57, -56,
-57, -56, -57, -56, -56, -57, -57, -57, -57, -57, -57, -56, -56, -56, -56, -56,
-56, -56, -56, -57, -56, -57, -57, -57, -57, -56, -56, -57, -56, -57, -56, -56,
-57, -56, -56, -56, -57, -56, -56, -56, -56, -57, -56, -57, -57, -56, -56, -56,
-56, -56, -57, -56, -57, -56, -57, -55, -56, -56, -57, -56, -56, -56, -56, -57,
-56, -56, -56, -57, -55, -55, -56, -56, -56, -56, -56, -56, -55, -56, -56, -56,
-56, -56, -56, -56, -56, -56, -56, -56, -56, -56, -56, -56, -56, -56, -57, -56,
-55, -56, -56, -56, -56, -56, -56, -56, -55, -56, -55, -55, -55, -56, -56, -56,
-56, -56, -56, -55, -55, -56, -56, -56, -55, -55, -56, -55, -56, -56, -56, -56,
-56, -56, -56, -55, -56, -55, -55, -55, -56, -55, -55, -56, -56, -56, -55, -55,
-55, -55, -55, -55, -55, -55, -56, -55, -56, -56, -55, -56, -56, -55, -55, -55,
-56, -55, -56, -56, -55, -56, -55, -56, -56, -55, -55, -55, -55, -55, -55, -56,
-55, -55, -55, -56, -55, -56, -56, -55, -55, -55, -55, -55, -56, -55, -55, -55,
-55, -55, -55, -55, -54, -56, -56, -55, -55, -55, -54, -56, -55, -55, -55, -56,
-55, -56, -55, -56, -54, -55, -55, -55, -55, -54, -55, -55, -54, -55, -56, -55,
-55, -55, -55, -55, -55, -54, -55, -55, -54, -56, -55, -55, -55, -55, -54, -55,
-55, -56, -55, -55, -55, -55, -54, -54, -55, -55, -55, -55, -54, -55, -54, -55,
-54, -56, -54, -55, -54, -55, -54, -12, };