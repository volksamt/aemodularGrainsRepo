#define DATA_LENGTH 512
#define DATA AKWF_squ_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 29, 39, 48, 55, 60, 65, 68, 70,
73, 75, 77, 77, 80, 80, 83, 83, 85, 86, 87, 90, 90, 92, 93, 94, 96, 98, 99, 100,
101, 102, 103, 104, 105, 106, 106, 108, 109, 109, 110, 111, 111, 113, 113, 113,
114, 115, 114, 114, 116, 115, 116, 117, 117, 117, 117, 118, 118, 118, 118, 118,
118, 118, 119, 119, 118, 119, 119, 118, 118, 118, 119, 119, 119, 119, 119, 119,
119, 120, 120, 119, 119, 118, 119, 120, 119, 119, 118, 119, 119, 120, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 118, 119, 120, 118, 118, 120, 119, 119, 119, 119,
118, 119, 119, 118, 118, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 120,
119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 118, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 118, 119, 119, 120, 119, 118, 119, 120, 118, 119, 119, 119, 119, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 118, 108, 90, 65,
40, 20, 1, -15, -29, -40, -49, -56, -60, -64, -68, -71, -73, -75, -76, -79, -80,
-81, -83, -83, -85, -85, -87, -89, -91, -92, -94, -95, -96, -98, -98, -99, -101,
-102, -103, -105, -106, -106, -107, -108, -109, -109, -110, -112, -111, -112,
-112, -113, -114, -114, -114, -115, -115, -116, -116, -116, -117, -116, -117,
-117, -118, -118, -118, -119, -118, -118, -119, -119, -119, -118, -119, -118,
-119, -118, -118, -119, -119, -119, -118, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -120, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -118, -119, -119, -119, -118, -119, -119, -120,
-119, -120, -118, -119, -118, -119, -118, -119, -119, -120, -120, -119, -119,
-120, -119, -118, -119, -119, -118, -119, -119, -120, -119, -119, -119, -118,
-118, -119, -119, -120, -120, -119, -119, -119, -118, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119,
-120, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -120,
-119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -120, -118, -119, -119, -120, -118, -120,
-120, -120, -119, -120, -118, -120, -119, -119, -119, -120, -118, -118, -108,
-90, -64, -40, -19, -1, };