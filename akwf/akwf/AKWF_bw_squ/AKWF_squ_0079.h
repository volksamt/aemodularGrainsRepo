#define DATA_LENGTH 512
#define DATA AKWF_squ_0079

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 6, 9, 10, 12, 13, 15, 18, 20,
21, 23, 25, 26, 28, 29, 31, 33, 35, 37, 38, 40, 42, 44, 45, 47, 48, 50, 52, 54,
56, 57, 59, 60, 63, 65, 66, 68, 70, 71, 74, 75, 76, 78, 80, 81, 84, 85, 87, 89,
91, 92, 94, 95, 98, 99, 102, 102, 104, 106, 108, 110, 112, 113, 115, 116, 118,
118, 119, 120, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 120, 119, 120,
118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 118, 118, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 120, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 120, 118, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 118, 118, 119, 119, 119,
119, 120, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120,
119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 120, 118, 119, 118, 119, 119, 119, 119, 118,
120, 119, 119, 119, 119, 117, 120, 118, 122, 115, 126, 7, -124, -116, -121,
-117, -121, -118, -119, -118, -120, -119, -119, -120, -119, -119, -119, -120,
-118, -119, -118, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -118, -119, -119, -119, -118, -118, -119, -119, -119, -119, -120,
-119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -119, -119,
-120, -120, -119, -120, -119, -119, -119, -120, -118, -119, -119, -118, -118,
-118, -120, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119,
-119, -120, -118, -119, -118, -119, -118, -120, -119, -119, -120, -119, -119,
-119, -119, -119, -120, -120, -120, -119, -118, -120, -119, -119, -119, -118,
-119, -119, -119, -119, -120, -119, -119, -119, -120, -118, -118, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119, -120,
-120, -118, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -118,
-119, -119, -119, -118, -119, -119, -120, -119, -118, -120, -119, -120, -119,
-119, -118, -120, -118, -120, -118, -121, -117, -121, -117, -120, -117, -120,
-117, -121, -117, -121, -114, -5, };