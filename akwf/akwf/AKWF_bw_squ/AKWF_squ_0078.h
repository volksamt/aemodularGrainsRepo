#define DATA_LENGTH 512
#define DATA AKWF_squ_0078

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 5, 8, 9, 12, 13, 16, 17, 19, 21,
24, 25, 28, 29, 32, 33, 35, 38, 40, 42, 43, 45, 48, 50, 51, 54, 56, 57, 59, 61,
63, 66, 68, 70, 71, 73, 75, 78, 79, 81, 83, 86, 87, 90, 91, 93, 96, 98, 100,
102, 104, 105, 108, 109, 111, 114, 115, 118, 119, 120, 119, 119, 119, 119, 119,
119, 119, 120, 120, 120, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 120, 119,
119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 120, 120, 119, 118, 119, 119, 120, 120,
118, 119, 119, 120, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 118, 120,
120, 119, 119, 118, 119, 119, 120, 118, 119, 118, 120, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 120, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 120, 119,
119, 118, 118, 119, 119, 119, 119, 119, 120, 119, 119, 120, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 118, 120, 119, 120, 119, 119, 119, 119,
119, 120, 118, 119, 119, 119, 120, 119, 121, 117, 121, 115, 127, 7, -123, -116,
-120, -117, -120, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119,
-120, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -120,
-118, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -120, -120,
-119, -120, -119, -120, -119, -118, -120, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -120, -118, -119,
-119, -120, -119, -119, -118, -119, -120, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -119,
-119, -118, -118, -119, -119, -119, -119, -118, -119, -118, -119, -120, -120,
-119, -119, -120, -119, -120, -120, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -120, -120, -119, -119, -120, -118, -120, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -120, -118, -119, -120, -120, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -118, -119, -119, -118, -119,
-118, -119, -119, -118, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -120, -119, -120, -118, -120, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -120, -118, -120,
-119, -119, -118, -120, -118, -120, -118, -120, -117, -121, -117, -121, -117,
-121, -117, -121, -116, -122, -115, -5, };