#define DATA_LENGTH 512
#define DATA AKWF_squ_0077

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 12, 13, 15, 18, 21, 22,
26, 27, 30, 33, 34, 36, 39, 42, 43, 46, 48, 51, 53, 56, 58, 60, 62, 65, 67, 70,
72, 74, 77, 78, 81, 83, 86, 88, 91, 92, 95, 98, 100, 102, 104, 106, 110, 111,
113, 117, 119, 119, 119, 119, 119, 120, 119, 119, 118, 118, 119, 119, 119, 119,
120, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 118, 119, 119, 119, 120,
119, 119, 119, 118, 120, 119, 119, 120, 118, 119, 119, 120, 119, 119, 119, 119,
118, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 120, 120,
119, 119, 120, 119, 119, 119, 120, 119, 120, 119, 119, 120, 119, 119, 119, 119,
119, 120, 119, 119, 118, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119,
120, 120, 119, 120, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119,
119, 119, 119, 119, 118, 118, 120, 119, 119, 120, 120, 119, 119, 118, 118, 119,
119, 119, 119, 119, 119, 120, 118, 120, 119, 119, 119, 119, 118, 120, 118, 119,
118, 118, 118, 118, 118, 118, 120, 119, 120, 119, 121, 117, 122, 116, 127, 7,
-124, -117, -121, -118, -120, -119, -120, -119, -119, -119, -119, -119, -119,
-120, -119, -120, -118, -120, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119,
-120, -120, -119, -120, -119, -119, -119, -118, -118, -119, -119, -119, -119,
-119, -119, -120, -119, -118, -120, -119, -119, -120, -119, -119, -119, -119,
-119, -120, -119, -118, -118, -119, -118, -119, -118, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118,
-119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -118, -119,
-120, -118, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -118,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -118,
-119, -120, -119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -120, -120, -119, -119, -119, -120, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119,
-120, -120, -119, -119, -119, -118, -118, -120, -119, -120, -119, -119, -119,
-118, -120, -119, -119, -118, -120, -118, -121, -118, -121, -117, -121, -118,
-121, -118, -121, -116, -121, -117, -121, -115, -5, };