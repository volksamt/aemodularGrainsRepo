#define DATA_LENGTH 512
#define DATA AKWF_squ_0095

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 1, 2, 3, 3, 4, 5, 6, 5, 6, 7, 7,
8, 9, 8, 9, 11, 10, 11, 13, 13, 14, 14, 14, 15, 16, 16, 17, 18, 18, 18, 19, 20,
20, 20, 21, 21, 22, 23, 24, 25, 25, 26, 25, 26, 27, 27, 29, 29, 30, 30, 31, 31,
32, 33, 33, 33, 33, 35, 36, 36, 37, 37, 38, 38, 39, 39, 41, 41, 42, 42, 42, 43,
43, 44, 44, 46, 46, 47, 47, 47, 48, 49, 49, 49, 50, 51, 51, 52, 53, 53, 53, 55,
55, 55, 56, 56, 58, 58, 58, 59, 59, 61, 60, 62, 62, 62, 63, 64, 64, 65, 66, 67,
68, 68, 68, 69, 69, 69, 70, 71, 71, 72, 72, 73, 74, 75, 75, 75, 76, 77, 77, 78,
78, 78, 79, 80, 81, 81, 82, 82, 83, 84, 84, 85, 85, 85, 86, 87, 88, 89, 89, 89,
90, 91, 92, 92, 92, 94, 93, 95, 95, 95, 96, 96, 98, 98, 98, 98, 99, 100, 101,
101, 102, 102, 102, 104, 104, 105, 106, 106, 107, 107, 108, 107, 108, 109, 110,
111, 111, 112, 112, 113, 114, 113, 114, 115, 115, 116, 117, 117, 119, 118, 119,
119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 120,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 120, 118, 121, 118, 122,
115, 126, 6, -123, -117, -121, -118, -120, -119, -120, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-118, -120, -118, -119, -119, -120, -120, -119, -120, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119,
-119, -118, -118, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-120, -120, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -120,
-119, -119, -118, -118, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -120, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -120, -118, -119, -119, -120, -119, -120, -118,
-120, -117, -121, -117, -121, -117, -122, -117, -122, -115, -5, };