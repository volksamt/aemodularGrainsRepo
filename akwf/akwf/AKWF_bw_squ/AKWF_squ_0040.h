#define DATA_LENGTH 512
#define DATA AKWF_squ_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 55, 105, 120, 117, 117, 116, 115,
115, 114, 114, 112, 113, 111, 111, 111, 110, 109, 109, 107, 107, 106, 105, 105,
105, 104, 104, 103, 102, 102, 101, 101, 99, 99, 99, 97, 98, 97, 96, 96, 96, 95,
95, 93, 93, 92, 92, 91, 91, 89, 90, 89, 88, 88, 88, 86, 86, 86, 86, 85, 84, 83,
84, 83, 83, 81, 81, 80, 80, 79, 79, 78, 78, 77, 77, 76, 65, 19, -32, -47, -45,
-45, -45, -44, -44, -44, -44, -42, -43, -42, -42, -42, -42, -43, -42, -42, -41,
-41, -42, -41, -40, -40, -39, -40, -40, -40, -40, -39, -39, -39, -38, -39, -38,
-39, -38, -38, -37, -38, -36, -36, -37, -37, -36, -37, -36, -35, -35, -36, -35,
-35, -35, -35, -35, -35, -33, -34, -34, -33, -33, -33, -33, -33, -32, -33, -32,
-32, -32, -31, -31, -32, -31, -32, -31, -30, -30, -30, -31, -31, -30, -31, -30,
-29, -29, -29, -29, -29, -29, -29, -29, -28, -27, -27, -28, -28, -27, -27, -28,
-27, -27, -27, -27, -26, -26, -26, -26, -26, -26, -27, -25, -26, -25, -25, -25,
-25, -24, -24, -25, -24, -24, -24, -24, -24, -24, -23, -23, -24, -23, -24, -23,
-23, -23, -22, -23, -22, -21, -22, -22, -22, -22, -21, -21, -21, -22, -21, -21,
-21, -20, -21, -21, -20, -21, -20, -20, -20, -19, -19, -19, -19, -19, -19, -19,
-18, -18, -19, -19, -18, -18, -18, -18, -18, -17, -18, -18, -18, -17, -17, -18,
-17, -17, -17, -17, -16, -17, -17, -17, -17, -16, -16, -16, -16, -16, -15, -16,
-16, -16, -16, -15, -15, -15, -15, -15, -15, -15, -14, -14, -14, -14, -15, -15,
-14, -14, -15, -14, -14, -14, -13, -13, -13, -13, -13, -13, -13, -14, -13, -13,
-13, -12, -13, -13, -12, -13, -12, -12, -12, -11, -13, -12, -12, -12, -11, -11,
-11, -11, -11, -11, -10, -11, -12, -11, -11, -11, -11, -11, -11, -10, -10, -11,
-10, -10, -9, -10, -10, -10, -10, -9, -10, -10, -9, -9, -9, -9, -10, -9, -8,
-10, -9, -8, -9, -9, -9, -9, -8, -8, -9, -8, -8, -8, -9, -8, -8, -8, -8, -8, -7,
-8, -7, -7, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -6, -7, -7, -7, -7, -7,
-6, -6, -7, -7, -7, -6, -7, -6, -7, -6, -7, -5, -5, -6, -6, -5, -7, -6, -6, -5,
-5, -5, -5, -6, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5,
-5, -5, -5, -4, -5, -4, -5, -4, -4, -4, -4, -4, -4, -4, -4, -4, -3, -3, -4, -4,
-4, -4, -3, -4, -3, -3, -4, -3, -3, -4, -3, -3, -3, -4, -3, -3, -3, -2, -3, -3,
-3, -3, -2, -3, -3, -3, -3, -3, -3, -3, -2, -2, -3, -3, -2, -3, -3, -2, -2, -2,
-2, -3, -1, -3, -2, -2, -2, -2, -2, -2, -2, -2, -2, -3, -1, -2, -3, -1, };