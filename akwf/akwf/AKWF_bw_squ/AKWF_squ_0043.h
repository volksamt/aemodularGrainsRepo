#define DATA_LENGTH 512
#define DATA AKWF_squ_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 48, 101, 119, 118, 117, 116, 116,
114, 114, 114, 113, 112, 112, 111, 111, 109, 109, 109, 108, 107, 107, 106, 105,
104, 104, 104, 102, 102, 102, 101, 100, 100, 99, 99, 97, 97, 97, 96, 96, 95, 95,
94, 93, 93, 92, 92, 92, 90, 89, 89, 89, 81, 38, -15, -34, -32, -32, -31, -32,
-32, -32, -32, -31, -31, -30, -31, -31, -30, -31, -30, -31, -30, -29, -30, -28,
-29, -29, -29, -28, -29, -28, -28, -28, -28, -28, -28, -27, -27, -26, -27, -28,
-28, -27, -26, -27, -27, -27, -26, -26, -26, -26, -25, -26, -25, -26, -25, -24,
-25, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -23, -23, -24, -23, -23,
-23, -23, -22, -22, -22, -23, -22, -22, -22, -22, -22, -21, -21, -22, -21, -21,
-21, -21, -21, -21, -20, -21, -21, -20, -20, -20, -20, -20, -20, -20, -20, -20,
-19, -19, -19, -19, -19, -19, -18, -19, -19, -18, -18, -18, -18, -18, -18, -18,
-18, -17, -18, -17, -18, -18, -17, -17, -17, -17, -17, -16, -17, -16, -17, -17,
-16, -16, -16, -15, -16, -15, -15, -16, -15, -16, -16, -15, -15, -15, -15, -14,
-14, -15, -15, -15, -14, -14, -15, -14, -14, -14, -15, -14, -14, -14, -14, -14,
-14, -14, -13, -13, -13, -12, -13, -13, -13, -12, -13, -12, -13, -13, -12, -12,
-12, -12, -11, -12, -12, -12, -12, -12, -12, -12, -12, -12, -12, -12, -11, -11,
-11, -11, -11, -10, -10, -10, -11, -11, -11, -10, -10, -11, -11, -11, -11, -10,
-10, -10, -10, -9, -10, -10, -10, -9, -9, -9, -10, -9, -9, -10, -9, -9, -9, -9,
-10, -8, -9, -9, -9, -9, -8, -9, -8, -8, -9, -9, -8, -8, -8, -8, -9, -8, -7, -8,
-8, -8, -8, -7, -8, -7, -8, -7, -7, -7, -8, -7, -7, -7, -8, -7, -7, -7, -7, -7,
-7, -7, -7, -7, -6, -6, -7, -6, -7, -6, -7, -7, -6, -6, -6, -6, -6, -6, -6, -6,
-6, -6, -6, -6, -6, -6, -6, -5, -5, -6, -6, -6, -6, -6, -5, -5, -6, -5, -5, -5,
-5, -5, -6, -5, -5, -5, -4, -5, -4, -5, -5, -4, -5, -4, -4, -4, -4, -4, -5, -4,
-4, -5, -5, -4, -5, -4, -4, -5, -4, -5, -4, -3, -4, -4, -4, -3, -4, -3, -3, -4,
-4, -4, -4, -4, -4, -4, -3, -3, -4, -3, -3, -4, -3, -4, -3, -2, -3, -3, -3, -3,
-3, -3, -3, -3, -3, -3, -3, -3, -3, -2, -3, -3, -3, -2, -2, -3, -3, -2, -2, -2,
-3, -2, -2, -3, -2, -2, -2, -2, -2, -2, -2, -2, -2, -3, -2, -2, -3, -2, -2, -3,
-2, -1, -3, -2, -2, -1, -2, -1, -1, -2, -2, -1, -2, -1, -1, -1, -2, -2, -1, -1,
-1, -1, -1, -1, -1, -2, -2, -1, -1, -2, -2, -2, -1, -1, 0, -1, -1, -1, -1, -2,
-1, 0, -1, -1, -1, -1, };