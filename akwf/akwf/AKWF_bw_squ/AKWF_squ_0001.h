#define DATA_LENGTH 512
#define DATA AKWF_squ_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {62, 116, 103, 111, 106, 109, 106, 109,
107, 108, 107, 107, 107, 106, 108, 107, 107, 106, 107, 106, 107, 107, 106, 106,
106, 105, 106, 105, 106, 106, 105, 105, 105, 104, 105, 105, 105, 104, 105, 104,
104, 104, 104, 104, 104, 104, 104, 103, 103, 103, 104, 103, 103, 103, 103, 103,
103, 103, 102, 102, 102, 102, 102, 102, 102, 101, 102, 102, 101, 102, 101, 100,
102, 100, 100, 100, 101, 101, 101, 100, 100, 100, 100, 101, 100, 100, 100, 100,
99, 100, 99, 99, 99, 99, 99, 99, 98, 99, 98, 98, 99, 98, 98, 98, 97, 97, 98, 98,
97, 97, 97, 97, 97, 96, 98, 97, 97, 97, 97, 96, 97, 97, 96, 96, 96, 97, 96, 96,
95, 96, 95, 96, 94, 95, 95, 95, 95, 95, 95, 95, 95, 94, 94, 94, 94, 94, 94, 94,
94, 94, 94, 93, 94, 93, 93, 93, 94, 94, 93, 94, 93, 93, 92, 93, 92, 93, 91, 92,
92, 92, 92, 92, 92, 91, 92, 92, 91, 91, 92, 91, 91, 91, 90, 91, 91, 91, 91, 91,
91, 90, 90, 90, 90, 89, 90, 90, 90, 89, 89, 89, 89, 89, 88, 89, 89, 88, 89, 89,
89, 89, 88, 89, 88, 88, 88, 88, 88, 88, 88, 87, 87, 87, 87, 88, 86, 88, 87, 87,
87, 87, 86, 87, 87, 87, 87, 86, 86, 86, 87, 85, 86, 85, 86, 84, 87, 83, 87, 83,
88, 83, 87, 82, 88, 80, 91, 63, -93, -112, -105, -111, -106, -110, -106, -109,
-106, -109, -106, -109, -105, -108, -107, -108, -107, -108, -106, -107, -106,
-107, -107, -107, -106, -106, -107, -106, -106, -105, -106, -106, -105, -105,
-106, -105, -105, -105, -105, -105, -105, -104, -105, -105, -104, -104, -104,
-104, -104, -104, -104, -104, -104, -103, -103, -103, -103, -103, -103, -103,
-103, -102, -103, -102, -102, -103, -102, -101, -101, -101, -101, -101, -101,
-102, -101, -101, -102, -101, -101, -100, -101, -101, -100, -100, -100, -100,
-100, -100, -100, -100, -99, -99, -99, -100, -99, -99, -100, -98, -100, -98,
-98, -99, -99, -99, -98, -98, -98, -97, -97, -98, -98, -97, -98, -98, -98, -97,
-97, -98, -98, -97, -96, -97, -97, -97, -96, -96, -96, -96, -95, -96, -96, -96,
-96, -95, -95, -96, -96, -95, -95, -95, -95, -95, -94, -95, -95, -94, -95, -94,
-95, -94, -94, -94, -94, -94, -93, -94, -93, -93, -93, -93, -93, -93, -93, -93,
-93, -93, -92, -92, -92, -92, -92, -92, -92, -91, -92, -91, -92, -92, -91, -92,
-91, -91, -91, -91, -91, -91, -91, -91, -90, -90, -90, -90, -90, -90, -90, -89,
-90, -90, -89, -89, -89, -90, -89, -90, -89, -89, -89, -89, -89, -89, -88, -88,
-88, -88, -87, -88, -88, -88, -89, -88, -88, -88, -88, -87, -87, -87, -86, -87,
-87, -88, -87, -88, -87, -88, -85, -87, -86, -86, -85, -87, -87, -86, -86, -86,
-86, -85, -86, -85, -85, -86, -86, -84, -87, -82, -92, -43, };