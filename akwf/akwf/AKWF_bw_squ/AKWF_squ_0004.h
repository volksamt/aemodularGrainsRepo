#define DATA_LENGTH 512
#define DATA AKWF_squ_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 92, 88, 123, 109, 112, 108, 109,
109, 109, 110, 110, 111, 110, 111, 110, 111, 111, 113, 111, 113, 111, 112, 111,
113, 111, 113, 112, 113, 113, 113, 113, 112, 114, 114, 114, 113, 113, 114, 114,
114, 114, 114, 114, 115, 114, 115, 114, 114, 115, 115, 115, 115, 115, 115, 115,
115, 115, 115, 115, 116, 115, 115, 116, 116, 116, 115, 115, 116, 116, 116, 115,
115, 115, 115, 114, 115, 115, 115, 116, 115, 115, 115, 116, 116, 115, 115, 115,
114, 115, 115, 114, 115, 114, 114, 114, 114, 114, 114, 114, 114, 114, 113, 114,
113, 113, 114, 114, 114, 114, 113, 114, 114, 114, 114, 114, 114, 113, 114, 113,
113, 113, 113, 113, 113, 113, 112, 113, 113, 113, 112, 113, 112, 113, 112, 112,
112, 113, 113, 112, 112, 112, 111, 112, 113, 111, 112, 112, 112, 111, 111, 112,
112, 112, 112, 112, 112, 111, 112, 112, 112, 112, 111, 112, 111, 111, 112, 111,
112, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 110, 111, 112, 112,
110, 111, 112, 111, 111, 111, 110, 112, 111, 111, 111, 110, 111, 111, 111, 111,
110, 110, 110, 111, 111, 111, 111, 110, 110, 111, 110, 111, 110, 111, 111, 110,
111, 111, 111, 111, 111, 111, 110, 111, 111, 111, 111, 111, 111, 111, 111, 110,
112, 111, 111, 110, 111, 109, 111, 110, 112, 110, 112, 110, 112, 109, 112, 109,
111, 109, 111, 111, 110, 111, 109, 110, -51, -93, -89, -126, -106, -115, -106,
-112, -107, -111, -109, -112, -110, -112, -110, -111, -110, -112, -112, -111,
-112, -111, -113, -112, -112, -112, -112, -111, -112, -113, -114, -113, -112,
-113, -114, -113, -114, -114, -114, -113, -114, -115, -114, -115, -114, -114,
-115, -115, -115, -115, -114, -115, -114, -115, -115, -115, -115, -115, -116,
-115, -115, -115, -116, -115, -115, -116, -115, -116, -115, -116, -115, -116,
-115, -116, -115, -115, -114, -115, -115, -115, -115, -115, -115, -114, -115,
-114, -115, -114, -115, -115, -114, -115, -114, -114, -115, -115, -114, -114,
-114, -114, -115, -114, -114, -114, -114, -113, -114, -114, -114, -114, -114,
-113, -113, -113, -114, -113, -113, -112, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -112, -112, -113, -112, -112, -113, -113, -112, -112, -113,
-113, -112, -112, -112, -113, -112, -112, -112, -112, -112, -112, -112, -111,
-111, -112, -112, -111, -112, -112, -112, -111, -111, -112, -112, -112, -112,
-112, -112, -111, -112, -111, -111, -111, -112, -111, -112, -110, -112, -112,
-110, -111, -112, -111, -111, -111, -112, -111, -111, -111, -111, -111, -112,
-112, -111, -111, -111, -111, -111, -111, -111, -111, -110, -111, -111, -110,
-111, -111, -111, -111, -111, -111, -111, -111, -110, -110, -111, -111, -111,
-112, -111, -111, -111, -111, -111, -111, -111, -111, -111, -111, -110, -111,
-110, -110, -111, -111, -110, -111, -110, -111, -111, -110, -110, -111, -111,
-110, -112, -110, -111, -109, -112, -109, -112, -108, -113, -108, -114, -106,
-118, -95, };