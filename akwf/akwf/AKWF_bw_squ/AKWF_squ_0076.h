#define DATA_LENGTH 512
#define DATA AKWF_squ_0076

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 7, 12, 14, 17, 19, 23, 25, 27,
30, 33, 35, 38, 42, 44, 47, 50, 53, 55, 58, 61, 63, 67, 69, 71, 75, 78, 81, 83,
86, 89, 91, 94, 97, 99, 102, 106, 108, 111, 114, 117, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 120,
119, 119, 119, 119, 119, 120, 119, 120, 120, 119, 119, 119, 119, 119, 119, 120,
119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 120, 119, 119, 118, 120, 119, 119, 119, 119, 119, 118, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
120, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 120, 118, 119, 119,
119, 119, 119, 120, 120, 120, 119, 119, 120, 119, 119, 119, 120, 119, 119, 118,
118, 118, 119, 118, 120, 118, 119, 119, 120, 119, 119, 119, 119, 118, 120, 119,
119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 118, 121, 117, 121, 115, 127,
7, -124, -116, -120, -118, -120, -118, -119, -119, -119, -119, -119, -120, -118,
-120, -119, -120, -119, -120, -118, -120, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -118, -120, -118, -119,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119,
-120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -120, -119, -119, -120, -119, -119, -118, -120, -119, -119, -119,
-119, -120, -120, -118, -119, -119, -119, -119, -118, -119, -119, -119, -120,
-119, -119, -118, -120, -119, -119, -119, -118, -119, -119, -119, -120, -119,
-119, -119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -118, -118, -119, -119, -119, -120, -120, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -120, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-118, -119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -118, -118, -119, -119, -119, -119, -118, -119,
-119, -120, -119, -120, -118, -120, -117, -121, -118, -121, -118, -120, -117,
-121, -117, -121, -117, -121, -117, -122, -115, -5, };