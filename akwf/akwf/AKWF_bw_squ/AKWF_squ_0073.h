#define DATA_LENGTH 512
#define DATA AKWF_squ_0073

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 14, 20, 27, 34, 41, 48, 55, 62, 69,
76, 83, 90, 97, 104, 111, 117, 120, 119, 119, 119, 119, 118, 120, 120, 119, 119,
120, 119, 118, 120, 120, 119, 120, 120, 119, 118, 119, 119, 120, 120, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 120, 119,
120, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 118, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119,
119, 120, 120, 119, 120, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119,
120, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 120, 118, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120,
117, 122, 115, 126, 7, -123, -116, -121, -117, -120, -118, -119, -119, -119,
-119, -120, -120, -119, -120, -118, -119, -119, -120, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120,
-119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -120, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120,
-118, -119, -120, -120, -119, -119, -119, -119, -118, -120, -119, -119, -120,
-119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119,
-119, -119, -119, -119, -118, -119, -119, -118, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -120, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -118, -119,
-119, -119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -118, -120,
-119, -119, -119, -120, -119, -120, -119, -119, -118, -119, -119, -119, -119,
-119, -120, -118, -119, -118, -120, -118, -119, -118, -119, -118, -120, -119,
-119, -119, -119, -119, -118, -119, -119, -120, -118, -120, -118, -121, -118,
-120, -118, -120, -117, -120, -118, -121, -117, -122, -118, -122, -115, -5, };