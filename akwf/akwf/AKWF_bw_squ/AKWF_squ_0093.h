#define DATA_LENGTH 512
#define DATA AKWF_squ_0093

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 3, 4, 5, 5, 6, 6, 7, 7, 8,
9, 9, 10, 11, 11, 12, 13, 13, 14, 14, 16, 16, 17, 17, 18, 18, 19, 19, 20, 21,
22, 22, 23, 24, 24, 24, 24, 26, 27, 27, 29, 28, 29, 29, 31, 31, 32, 32, 33, 34,
34, 35, 36, 36, 36, 38, 39, 39, 38, 39, 41, 41, 42, 42, 43, 44, 44, 45, 45, 47,
47, 47, 48, 48, 49, 51, 51, 52, 51, 53, 53, 54, 54, 55, 56, 57, 56, 58, 58, 58,
60, 61, 61, 61, 62, 63, 64, 64, 64, 65, 67, 66, 67, 68, 69, 69, 69, 71, 71, 72,
73, 73, 73, 74, 75, 76, 76, 77, 77, 77, 79, 79, 79, 81, 82, 82, 83, 83, 84, 83,
84, 85, 86, 86, 88, 87, 89, 89, 90, 90, 91, 92, 92, 93, 93, 94, 95, 96, 96, 97,
98, 99, 99, 99, 100, 100, 102, 102, 102, 103, 104, 105, 106, 106, 107, 107, 108,
109, 109, 110, 110, 111, 111, 111, 113, 114, 114, 115, 116, 115, 117, 118, 117,
118, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 118, 118, 119, 118, 119, 120, 120, 118,
119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 120,
119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118,
120, 118, 121, 116, 127, 7, -124, -116, -120, -118, -120, -118, -120, -119,
-120, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -120, -118,
-119, -118, -119, -118, -120, -119, -119, -119, -120, -120, -119, -119, -120,
-119, -119, -119, -118, -120, -118, -119, -119, -118, -118, -119, -118, -119,
-119, -119, -119, -119, -120, -119, -120, -118, -119, -119, -119, -119, -119,
-120, -120, -119, -119, -119, -118, -119, -120, -120, -119, -119, -119, -118,
-119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -118, -119, -119, -119, -119, -120, -119, -119, -119, -120,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -120, -119, -119,
-119, -119, -120, -120, -119, -119, -120, -119, -119, -120, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -119,
-119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -118,
-120, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -120, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119,
-119, -120, -120, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -120, -119, -119, -120, -118, -119, -119, -120, -119,
-119, -119, -118, -118, -119, -119, -120, -119, -119, -118, -120, -118, -119,
-118, -119, -119, -119, -118, -119, -120, -119, -119, -118, -119, -118, -120,
-118, -121, -117, -121, -117, -121, -117, -121, -117, -121, -117, -122, -114,
-5, };