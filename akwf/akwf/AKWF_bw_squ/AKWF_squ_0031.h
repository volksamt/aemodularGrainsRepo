#define DATA_LENGTH 512
#define DATA AKWF_squ_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 55, 107, 120, 117, 117, 116, 116,
115, 114, 113, 113, 113, 112, 111, 110, 111, 109, 109, 108, 107, 107, 107, 106,
106, 105, 103, 103, 103, 103, 102, 101, 100, 100, 99, 99, 97, 97, 97, 96, 96,
96, 95, 94, 94, 94, 93, 92, 91, 90, 91, 90, 89, 89, 89, 88, 87, 87, 87, 86, 85,
84, 84, 84, 83, 83, 82, 81, 81, 81, 80, 80, 80, 80, 79, 78, 77, 76, 77, 76, 75,
75, 75, 74, 74, 73, 73, 72, 72, 72, 71, 71, 70, 70, 69, 69, 68, 67, 68, 67, 67,
66, 66, 65, 65, 65, 65, 64, 63, 63, 62, 62, 61, 62, 61, 60, 60, 60, 60, 59, 59,
58, 58, 57, 58, 57, 56, 56, 55, 56, 55, 54, 54, 55, 54, 53, 53, 52, 52, 51, 52,
50, 50, 49, 50, 49, 48, 49, 49, 48, 47, 48, 47, 47, 46, 46, 32, -19, -69, -81,
-79, -80, -79, -78, -78, -77, -78, -77, -76, -76, -76, -76, -75, -75, -74, -73,
-74, -74, -72, -72, -72, -72, -70, -70, -70, -70, -69, -70, -69, -69, -68, -68,
-67, -67, -67, -66, -66, -65, -65, -64, -65, -65, -64, -63, -63, -63, -63, -62,
-62, -62, -62, -61, -61, -60, -60, -60, -59, -59, -59, -58, -58, -58, -58, -58,
-57, -56, -56, -56, -55, -56, -55, -55, -54, -54, -55, -54, -54, -53, -53, -52,
-52, -52, -51, -51, -50, -51, -51, -49, -49, -50, -49, -49, -49, -48, -48, -47,
-47, -48, -47, -47, -46, -47, -45, -46, -45, -45, -45, -45, -44, -44, -44, -44,
-43, -44, -43, -42, -43, -43, -42, -42, -41, -41, -41, -41, -40, -40, -40, -41,
-39, -39, -40, -39, -38, -38, -37, -38, -37, -38, -37, -37, -37, -36, -36, -37,
-36, -36, -36, -35, -35, -35, -34, -34, -34, -34, -33, -33, -33, -34, -32, -33,
-33, -33, -32, -31, -31, -31, -31, -31, -30, -30, -31, -30, -30, -30, -30, -30,
-29, -29, -30, -29, -28, -28, -28, -28, -28, -28, -28, -27, -27, -28, -26, -27,
-26, -26, -27, -26, -26, -25, -25, -26, -25, -24, -25, -24, -25, -24, -25, -24,
-24, -23, -23, -22, -23, -23, -23, -22, -22, -22, -22, -23, -22, -21, -22, -21,
-21, -21, -21, -21, -21, -21, -21, -21, -20, -19, -20, -20, -19, -20, -19, -19,
-19, -18, -18, -18, -18, -19, -18, -18, -18, -17, -18, -18, -17, -17, -17, -17,
-17, -17, -16, -16, -17, -16, -16, -16, -15, -16, -16, -16, -15, -15, -15, -15,
-14, -15, -14, -14, -14, -15, -14, -14, -13, -13, -14, -13, -13, -13, -13, -12,
-13, -13, -13, -12, -12, -12, -13, -12, -12, -11, -13, -11, -12, -11, -12, -12,
-11, -10, -11, -11, -11, -10, -11, -11, -11, -10, -11, -10, -10, -10, -10, -10,
-10, -10, -10, -9, -9, -9, -10, -9, -10, -9, -9, -8, -9, -8, -9, -8, -8, -8, -8,
-8, -8, -8, -8, -7, -8, -7, -7, -8, -7, -6, -8, -6, };