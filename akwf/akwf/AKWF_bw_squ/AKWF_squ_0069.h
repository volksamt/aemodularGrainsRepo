#define DATA_LENGTH 512
#define DATA AKWF_squ_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {-51, -119, -117, -120, -119, -119,
-119, -118, -120, -118, -119, -118, -120, -119, -120, -118, -120, -119, -121,
-108, -50, -3, 5, 4, 5, 5, 5, 4, 6, 6, 5, 5, 5, 5, 5, 4, 5, 5, 4, 5, 5, 5, 5, 5,
5, 4, 6, 4, 5, 5, 5, 4, 4, 5, 5, 5, 5, 6, 5, 5, 4, 5, 4, 6, 4, 5, 4, 5, 5, 5, 5,
4, 5, 6, 4, 5, 5, 5, 6, 5, 4, 5, 5, 5, 6, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 6, 5,
4, 6, 4, 5, 5, 5, 5, 4, 6, 5, 5, 5, 4, 5, 5, 5, 5, 4, 5, 5, 5, 4, 5, 5, 5, 5, 5,
5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 4, 6, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 6,
4, 6, 5, 5, 5, 5, 5, 5, 5, 6, 5, 4, 5, 5, 5, 5, 5, 4, 5, 6, 5, 6, 6, 4, 5, 5, 5,
5, 5, 5, 5, 4, 5, 5, 5, 5, 4, 5, 4, 4, 5, 6, 6, 4, 5, 5, 5, 5, 5, 5, 5, 5, 6, 5,
5, 5, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 4, 5, 5, 5, 5, 6, 6, 5, 5, 4, 4, 5, 5, 5,
5, 5, 5, 4, 5, 5, 5, 4, 5, 5, 5, 5, 5, 4, 5, 5, 4, 5, 4, 5, 5, 5, 5, 5, 6, 5, 5,
5, 4, 4, 5, 5, 5, 5, 5, 5, 5, 6, 4, 5, 6, 4, 4, 5, 5, 5, 4, 4, 4, 5, 5, 5, 4, 6,
5, 5, 5, 5, 6, 5, 5, 5, 4, 5, 5, 5, 5, 5, 6, 4, 5, 5, 5, 5, 6, 5, 5, 5, 4, 5, 5,
5, 5, 4, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 4, 6, 5, 5, 5, 5, 5, 4, 4, 5, 4, 4, 5,
4, 4, 5, 4, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 6, 4, 4, 4,
5, 5, 5, 5, 4, 4, 5, 4, 5, 5, 5, 5, 5, 5, 4, 5, 4, 5, 5, 4, 5, 6, 4, 4, 5, 5, 5,
4, 5, 5, 5, 5, 4, 4, 5, 4, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 5, 5, 4, 5, 4,
5, 5, 4, 5, 5, 5, 5, 5, 4, 5, 5, 5, 4, 4, 5, 4, 4, 5, 4, 4, 5, 5, 5, 5, 4, 4, 5,
5, 5, 4, 4, 5, 5, 5, 4, 5, 5, 5, 5, 5, 4, 5, 5, 4, 5, 4, 5, 5, 5, 6, 5, 5, 5, 5,
4, 5, 5, 5, 5, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 5, 4, 5, 5, 4,
5, 5, 5, 5, 5, 4, 5, 5, 4, };