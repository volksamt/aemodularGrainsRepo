#define DATA_LENGTH 512
#define DATA AKWF_squ_0080

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 8, 9, 10, 11, 13, 15, 17,
18, 21, 22, 23, 25, 26, 28, 29, 30, 32, 34, 36, 37, 39, 40, 42, 43, 45, 47, 48,
50, 51, 52, 54, 55, 57, 59, 61, 62, 64, 65, 67, 68, 70, 71, 72, 73, 75, 77, 78,
81, 82, 83, 85, 87, 88, 90, 91, 94, 95, 96, 97, 99, 101, 103, 103, 105, 107,
109, 110, 111, 113, 114, 116, 118, 119, 119, 119, 118, 118, 119, 119, 119, 120,
119, 118, 119, 119, 119, 120, 119, 119, 119, 120, 119, 120, 118, 119, 119, 118,
119, 119, 119, 119, 120, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 120,
119, 118, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 118, 119, 119, 119, 120, 119,
119, 120, 119, 119, 120, 119, 119, 119, 119, 118, 120, 118, 119, 119, 119, 118,
119, 120, 119, 120, 118, 120, 118, 121, 115, 126, 6, -124, -116, -121, -118,
-120, -118, -119, -118, -119, -120, -119, -120, -119, -119, -119, -120, -118,
-119, -118, -119, -118, -120, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -118, -119, -120, -119, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -120, -119, -118,
-119, -119, -120, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119, -120,
-119, -118, -120, -119, -119, -119, -119, -118, -118, -120, -119, -119, -119,
-120, -119, -119, -119, -118, -120, -119, -120, -118, -119, -119, -119, -119,
-119, -120, -120, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -118, -119, -119, -119, -120, -119, -119, -119,
-120, -120, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -118, -118, -119, -118, -120, -118, -120,
-118, -120, -118, -121, -117, -120, -118, -121, -118, -121, -117, -121, -117,
-121, -117, -122, -115, -4, };