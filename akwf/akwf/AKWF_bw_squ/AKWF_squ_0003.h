#define DATA_LENGTH 512
#define DATA AKWF_squ_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 17, 25, 33, 41, 49, 56, 63, 68, 74,
80, 85, 90, 94, 97, 100, 103, 105, 107, 109, 111, 113, 113, 115, 116, 116, 116,
118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 118, 119, 119, 119, 118,
118, 118, 118, 118, 117, 117, 117, 116, 117, 116, 115, 116, 115, 116, 115, 116,
115, 115, 115, 114, 115, 115, 115, 115, 115, 115, 114, 114, 114, 114, 115, 115,
115, 114, 114, 114, 114, 115, 114, 114, 115, 113, 114, 114, 114, 114, 114, 114,
113, 114, 115, 113, 114, 114, 114, 114, 114, 114, 115, 113, 114, 114, 115, 114,
114, 114, 114, 114, 114, 114, 114, 114, 114, 114, 114, 115, 114, 114, 114, 114,
114, 115, 115, 114, 114, 114, 114, 114, 114, 114, 114, 114, 114, 113, 114, 115,
114, 113, 115, 115, 114, 114, 113, 114, 114, 114, 114, 115, 114, 114, 115, 115,
114, 115, 114, 114, 114, 114, 114, 114, 114, 114, 114, 114, 114, 113, 114, 115,
114, 114, 115, 115, 114, 114, 114, 114, 114, 114, 114, 113, 114, 114, 113, 114,
114, 114, 114, 114, 114, 114, 114, 114, 114, 114, 115, 114, 114, 115, 114, 115,
114, 114, 114, 114, 113, 113, 114, 114, 114, 115, 114, 114, 114, 115, 115, 114,
114, 114, 114, 115, 114, 115, 115, 114, 115, 114, 115, 115, 115, 114, 114, 114,
114, 114, 114, 114, 114, 114, 114, 114, 114, 113, 114, 117, 118, 108, 89, 68,
52, 39, 26, 13, 2, -8, -17, -25, -34, -41, -49, -56, -62, -69, -75, -80, -85,
-90, -94, -97, -99, -103, -105, -107, -109, -110, -112, -114, -114, -115, -117,
-118, -118, -118, -118, -118, -119, -118, -119, -120, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -118, -118, -117, -118, -117, -116, -117,
-116, -116, -116, -116, -116, -115, -116, -115, -116, -114, -115, -115, -114,
-115, -115, -115, -114, -115, -115, -114, -114, -115, -115, -114, -114, -114,
-115, -114, -114, -114, -114, -114, -115, -113, -114, -114, -115, -113, -114,
-113, -114, -113, -113, -115, -114, -114, -114, -114, -114, -114, -114, -114,
-115, -114, -114, -113, -113, -114, -114, -114, -114, -115, -113, -113, -114,
-114, -114, -115, -114, -114, -114, -114, -115, -115, -115, -115, -114, -114,
-114, -114, -113, -115, -114, -113, -115, -114, -114, -114, -115, -113, -114,
-114, -114, -115, -114, -114, -115, -113, -113, -114, -114, -114, -115, -114,
-114, -114, -114, -114, -114, -114, -114, -115, -114, -114, -114, -115, -114,
-114, -114, -114, -113, -115, -114, -114, -114, -114, -113, -114, -114, -114,
-115, -115, -114, -113, -114, -114, -114, -114, -113, -113, -114, -114, -114,
-114, -114, -114, -114, -113, -114, -114, -114, -114, -114, -114, -113, -114,
-114, -114, -114, -114, -115, -115, -114, -114, -113, -114, -114, -114, -114,
-115, -114, -114, -114, -114, -114, -114, -114, -114, -115, -114, -114, -114,
-113, -114, -114, -114, -114, -114, -114, -114, -114, -114, -114, -115, -117,
-116, -108, -90, -67, -52, -40, -27, -13, -2, };