#define DATA_LENGTH 512
#define DATA AKWF_squ_0083

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 6, 8, 8, 9, 10, 11, 12,
14, 15, 17, 18, 19, 20, 21, 22, 23, 24, 25, 27, 28, 28, 30, 31, 32, 33, 34, 36,
37, 39, 39, 41, 41, 43, 44, 45, 47, 48, 48, 50, 51, 52, 52, 54, 55, 57, 58, 59,
60, 61, 62, 65, 65, 65, 68, 69, 69, 71, 73, 73, 74, 76, 76, 78, 79, 80, 82, 82,
84, 85, 86, 88, 88, 90, 91, 92, 92, 94, 95, 96, 98, 99, 100, 100, 102, 103, 104,
106, 107, 108, 109, 110, 112, 113, 114, 114, 116, 117, 119, 118, 119, 119, 119,
119, 120, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120,
119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 120, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 118, 120, 119, 119, 118, 118, 119, 118, 119, 119, 119, 119,
119, 120, 119, 120, 118, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 120, 120, 120, 119, 120, 119, 119, 119,
120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 118, 119, 120,
119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 117,
121, 117, 121, 116, 127, 7, -124, -116, -121, -118, -120, -118, -119, -119,
-119, -119, -119, -120, -120, -119, -118, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-118, -119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -118, -119,
-120, -118, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -118,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -118, -120, -119, -120, -120, -118, -119, -119, -119,
-119, -119, -119, -120, -118, -120, -120, -118, -120, -119, -119, -119, -118,
-120, -118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -118, -120,
-119, -119, -119, -119, -120, -118, -118, -119, -119, -120, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -120, -119, -118, -119, -119, -119, -120, -119,
-119, -119, -119, -120, -119, -119, -118, -118, -119, -119, -119, -119, -119,
-119, -120, -119, -120, -119, -118, -119, -118, -118, -119, -118, -119, -120,
-118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -120, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -118, -120, -119, -119, -119, -118, -120, -119, -120,
-120, -118, -120, -119, -119, -118, -119, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -120, -118, -119, -118, -120,
-118, -121, -118, -121, -117, -121, -117, -122, -116, -121, -117, -122, -115,
-4, };