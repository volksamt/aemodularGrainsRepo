#define DATA_LENGTH 512
#define DATA AKWF_squ_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 125, 115, 122, 116, 122, 117,
121, 117, 121, 117, 120, 118, 120, 118, 120, 118, 119, 119, 119, 119, 120, 119,
119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 118, 119,
119, 120, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119,
120, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 120, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 120, 120,
119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 118,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 118, 118, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119,
120, 120, 119, 120, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 118, 119, 118, 119, 119, 120, 119, 119, 119,
119, 119, 119, 120, 119, 120, 118, 120, 118, 121, 117, 121, 117, 122, 116, 122,
117, 121, 116, 122, 116, 122, 116, 121, 116, 121, 117, -107, -124, -115, -122,
-117, -121, -118, -120, -119, -119, -121, -110, 119, 119, 118, 120, 117, 122,
116, 125, 110, 127, -73, -128, -110, -125, -114, -123, -115, -122, -116, -122,
-117, -121, -118, -121, -118, -120, -119, -120, -119, -119, -119, -119, -119,
-118, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -120,
-120, -119, -120, -119, -119, -119, -118, -119, -118, -119, -118, -120, -117,
-120, -117, -120, -116, -122, -116, -123, -113, -127, -100, };