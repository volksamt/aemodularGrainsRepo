#define DATA_LENGTH 512
#define DATA AKWF_squ_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {26, 89, 119, 117, 117, 116, 116, 114,
114, 113, 113, 112, 112, 110, 110, 110, 109, 108, 108, 108, 107, 107, 106, 106,
104, 103, 103, 103, 103, 101, 101, 101, 100, 99, 99, 98, 98, 97, 98, 96, 96, 95,
95, 95, 93, 93, 93, 92, 92, 91, 90, 90, 90, 89, 89, 89, 88, 88, 87, 86, 85, 85,
85, 85, 84, 83, 83, 83, 82, 82, 81, 80, 80, 79, 79, 78, 78, 78, 77, 77, 77, 76,
75, 75, 75, 74, 73, 73, 73, 73, 72, 71, 71, 71, 70, 70, 70, 69, 69, 69, 68, 68,
68, 66, 66, 66, 66, 65, 65, 64, 63, 63, 63, 63, 62, 62, 62, 61, 60, 60, 60, 59,
59, 59, 58, 58, 58, 57, 57, 57, 57, 56, 56, 56, 55, 55, 55, 54, 53, 53, 53, 52,
52, 52, 51, 52, 50, 50, 50, 50, 49, 49, 49, 49, 49, 48, 48, 48, 47, 46, 46, 46,
46, 46, 44, 45, 45, 44, 44, 44, 44, 43, 42, 43, 42, 42, 41, 42, 41, 40, 41, 41,
40, 40, 39, 39, 39, 39, 38, 38, 37, 37, 37, 37, 37, 36, 36, 36, 35, 35, 36, 35,
34, 34, 34, 33, 33, 33, 33, 33, 33, 32, 32, 32, 32, 31, 31, 31, 31, 30, 31, 30,
30, 30, 29, 29, 29, 29, 28, 29, 28, 28, 28, 27, 28, 27, 27, 26, 26, 25, 25, 25,
26, 26, 24, 25, 24, 25, 24, 25, 24, 23, 23, 22, 23, 15, -29, -92, -119, -118,
-117, -116, -115, -114, -114, -112, -112, -112, -111, -111, -110, -110, -109,
-108, -108, -108, -107, -107, -106, -105, -104, -104, -104, -102, -102, -101,
-101, -101, -100, -100, -99, -98, -98, -97, -97, -96, -96, -96, -94, -94, -94,
-93, -92, -92, -92, -91, -90, -90, -90, -89, -88, -89, -87, -87, -87, -85, -86,
-86, -84, -85, -83, -83, -82, -82, -81, -81, -81, -81, -80, -80, -78, -79, -78,
-77, -77, -77, -77, -77, -75, -75, -74, -74, -73, -73, -73, -73, -72, -71, -71,
-71, -71, -70, -70, -69, -69, -68, -68, -67, -68, -66, -66, -65, -65, -65, -64,
-65, -64, -63, -63, -63, -63, -61, -61, -61, -62, -61, -60, -59, -59, -59, -58,
-58, -58, -57, -57, -57, -56, -56, -55, -55, -54, -54, -54, -53, -53, -54, -53,
-53, -52, -52, -52, -51, -50, -51, -51, -50, -49, -49, -49, -48, -48, -47, -48,
-48, -46, -46, -46, -46, -45, -45, -45, -44, -45, -44, -44, -44, -44, -43, -43,
-43, -42, -42, -42, -41, -41, -41, -41, -40, -39, -40, -39, -40, -38, -38, -39,
-38, -38, -38, -37, -36, -37, -36, -37, -37, -36, -36, -35, -35, -35, -34, -33,
-34, -34, -33, -33, -32, -33, -32, -32, -32, -32, -31, -31, -32, -31, -30, -30,
-29, -30, -29, -29, -30, -29, -28, -28, -28, -28, -27, -28, -27, -27, -27, -26,
-27, -27, -26, -26, -25, -25, -25, -24, -24, -25, -24, -25, -24, -24, -23, -23,
-23, -23, -14, };