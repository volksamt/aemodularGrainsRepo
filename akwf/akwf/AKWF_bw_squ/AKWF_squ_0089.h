#define DATA_LENGTH 512
#define DATA AKWF_squ_0089

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 4, 4, 5, 6, 6, 7, 8, 9,
10, 11, 12, 13, 14, 14, 15, 15, 17, 17, 19, 18, 19, 20, 21, 22, 22, 23, 23, 25,
26, 27, 27, 28, 29, 29, 30, 32, 31, 32, 33, 34, 35, 36, 37, 37, 38, 38, 39, 40,
41, 42, 43, 44, 44, 45, 46, 46, 47, 48, 49, 50, 51, 51, 52, 53, 54, 55, 54, 55,
56, 58, 58, 59, 59, 61, 61, 62, 63, 64, 65, 65, 66, 66, 67, 68, 69, 70, 71, 71,
72, 73, 74, 74, 75, 76, 77, 78, 79, 78, 79, 81, 81, 82, 83, 84, 85, 84, 85, 87,
88, 88, 89, 90, 90, 92, 93, 93, 94, 95, 95, 96, 97, 98, 97, 99, 100, 100, 101,
102, 103, 104, 105, 105, 106, 107, 108, 109, 109, 110, 111, 112, 112, 113, 114,
115, 116, 116, 117, 118, 118, 118, 120, 118, 118, 120, 119, 119, 119, 119, 120,
119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 118, 119, 119,
119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119,
119, 120, 120, 119, 119, 118, 119, 118, 119, 118, 120, 119, 120, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 118, 119, 118, 119, 119,
119, 119, 119, 119, 118, 119, 118, 121, 118, 121, 115, 126, 6, -123, -117, -121,
-118, -120, -118, -120, -119, -120, -119, -119, -120, -118, -119, -118, -119,
-119, -119, -118, -119, -118, -119, -119, -119, -118, -120, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -118, -118, -119, -119, -120, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -120, -119, -120, -118, -119, -119, -118, -119, -118, -119, -120, -120,
-120, -119, -120, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -120, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -120, -118, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -119, -120,
-120, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120,
-119, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -120, -119, -119, -119, -119, -118,
-120, -118, -120, -118, -120, -117, -120, -117, -121, -118, -122, -117, -121,
-117, -121, -117, -121, -115, -5, };