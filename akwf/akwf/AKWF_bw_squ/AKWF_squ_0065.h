#define DATA_LENGTH 512
#define DATA AKWF_squ_0065

const PROGMEM int8_t DATA[DATA_LENGTH] = {51, 118, 118, 120, 118, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 120, 119, 118, 119, 119, 119,
119, 119, 119, 119, 118, 119, 118, 118, 119, 118, 119, 119, 119, 118, 119, 118,
118, 118, 119, 118, 119, 118, 119, 118, 118, 119, 118, 118, 119, 119, 118, 119,
118, 119, 118, 118, 119, 118, 118, 118, 118, 119, 118, 118, 119, 118, 118, 118,
119, 118, 118, 118, 119, 118, 118, 118, 119, 119, 118, 118, 118, 118, 118, 117,
118, 117, 118, 118, 117, 118, 118, 118, 118, 117, 118, 118, 118, 117, 118, 117,
118, 118, 117, 118, 117, 117, 117, 118, 118, 118, 117, 117, 118, 118, 117, 118,
118, 118, 117, 117, 117, 117, 117, 117, 118, 117, 118, 118, 117, 117, 118, 118,
117, 117, 117, 117, 117, 116, 117, 118, 117, 116, 117, 117, 117, 117, 116, 116,
117, 117, 117, 117, 117, 117, 117, 117, 117, 116, 116, 117, 117, 117, 117, 117,
116, 116, 117, 117, 117, 116, 117, 116, 117, 116, 116, 117, 117, 116, 116, 116,
116, 116, 116, 116, 117, 116, 116, 117, 116, 116, 116, 116, 116, 117, 116, 117,
116, 115, 116, 116, 116, 116, 117, 116, 116, 115, 117, 116, 117, 116, 117, 116,
117, 116, 117, 115, 117, 116, 116, 116, 115, 116, 116, 117, 115, 109, -27, -118,
-106, -114, -108, -112, -109, -111, -110, -112, -110, -111, -110, -111, -111,
-110, -111, -110, -111, -110, -111, -110, -110, -111, -111, -110, -111, -109,
-110, -110, -110, -111, -110, -110, -110, -110, -111, -110, -110, -110, -111,
-111, -110, -110, -110, -110, -111, -110, -110, -110, -110, -111, -110, -110,
-111, -111, -110, -110, -110, -110, -110, -110, -110, -110, -110, -111, -110,
-110, -110, -109, -110, -111, -109, -111, -111, -110, -110, -110, -110, -109,
-110, -110, -110, -110, -110, -109, -110, -110, -110, -110, -109, -110, -109,
-110, -109, -110, -110, -109, -109, -109, -110, -109, -110, -110, -110, -109,
-109, -109, -110, -110, -110, -109, -109, -110, -110, -109, -110, -109, -109,
-109, -109, -110, -109, -109, -110, -109, -109, -109, -109, -109, -109, -109,
-109, -109, -109, -109, -110, -109, -109, -109, -109, -109, -109, -109, -109,
-110, -109, -109, -109, -109, -109, -109, -109, -109, -109, -109, -109, -109,
-109, -108, -109, -108, -108, -109, -109, -109, -109, -109, -108, -108, -109,
-108, -108, -108, -109, -108, -109, -108, -109, -108, -108, -108, -109, -108,
-108, -108, -108, -109, -108, -109, -109, -108, -108, -108, -108, -108, -109,
-108, -108, -108, -109, -108, -107, -108, -109, -108, -108, -108, -109, -109,
-108, -109, -109, -108, -108, -108, -108, -108, -108, -108, -108, -107, -108,
-108, -107, -107, -107, -107, -108, -107, -108, -108, -108, -107, -108, -108,
-108, -107, -108, -107, -108, -107, -108, -107, -107, -108, -107, -108, -107,
-108, -107, -108, -107, -108, -106, -109, -107, -107, -107, -108, -106, -108,
-106, -108, -103, -26, };