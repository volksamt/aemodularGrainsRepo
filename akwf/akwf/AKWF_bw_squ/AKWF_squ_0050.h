#define DATA_LENGTH 512
#define DATA AKWF_squ_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 30, 84, 116, 119, 116, 116, 116,
112, 84, 28, -4, -6, -6, -5, -5, -5, -6, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5,
-4, -5, -5, -5, -6, -5, -4, -5, -5, -6, -4, -5, -5, -5, -4, -4, -5, -5, -4, -4,
-4, -4, -5, -5, -5, -4, -5, -4, -4, -4, -4, -4, -4, -4, -4, -5, -5, -4, -4, -4,
-3, -5, -4, -4, -4, -4, -4, -4, -3, -4, -3, -4, -3, -3, -4, -4, -4, -4, -3, -4,
-3, -4, -3, -4, -3, -4, -3, -4, -3, -4, -3, -3, -4, -4, -3, -3, -3, -3, -3, -3,
-4, -3, -4, -3, -3, -3, -3, -3, -4, -3, -3, -3, -4, -4, -3, -3, -3, -3, -3, -3,
-2, -3, -2, -2, -3, -3, -3, -3, -3, -2, -3, -3, -3, -3, -3, -3, -3, -2, -3, -3,
-3, -3, -3, -2, -2, -3, -3, -4, -3, -3, -3, -2, -3, -3, -3, -3, -2, -2, -2, -3,
-3, -3, -2, -2, -2, -3, -2, -2, -2, -2, -2, -3, -2, -3, -1, -2, -2, -2, -3, -2,
-2, -3, -3, -2, -3, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -1, -2,
-2, -2, -2, -2, -3, -2, -2, -2, -1, -2, -3, -1, -2, -2, -2, -2, -2, -2, -2, -1,
-2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -2, -2, -1, -2, -1, -2, -2, -1, -1, -2,
-2, -1, -1, -1, -2, -2, -2, -1, -2, -1, -2, -2, -2, -1, -1, -1, -1, -2, -2, -2,
-1, -1, -2, -1, -1, -2, -2, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -1, -2, -1,
-1, -1, 0, -2, -1, -2, -2, -1, -1, -1, -1, -1, -2, -1, -1, -1, -2, -1, -1, -1,
-1, -1, -1, -1, 0, -1, -1, -1, 0, -1, -1, 0, -1, -1, -1, -1, -1, -1, -2, -1, -1,
-1, -1, -2, -1, -1, -1, -1, 0, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, 0, -1, -1,
-1, -1, -1, -1, -1, 0, 0, -1, -1, -1, 0, -1, 0, -2, -1, 0, -1, 0, 0, 0, 0, -1,
0, -1, -1, 0, 0, -1, -1, 0, 0, 0, -1, 0, -1, -1, -1, -1, 0, -1, 0, -1, -1, -1,
0, -1, -1, 0, -1, -1, 0, -1, 0, 0, 0, -1, -1, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0,
-1, -1, 0, 0, 0, -1, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0,
-1, 0, 0, 0, 0, -1, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, 1, 0, -1, 0, -1, -1, 0, 1,
0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, };