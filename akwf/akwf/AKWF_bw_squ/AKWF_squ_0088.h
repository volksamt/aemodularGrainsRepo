#define DATA_LENGTH 512
#define DATA AKWF_squ_0088

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 2, 4, 5, 5, 7, 8, 8, 9, 9,
11, 12, 12, 13, 14, 14, 16, 17, 18, 18, 18, 19, 21, 21, 21, 23, 23, 25, 26, 27,
27, 28, 28, 29, 30, 31, 31, 32, 33, 35, 35, 36, 37, 38, 39, 40, 41, 41, 42, 42,
43, 44, 45, 46, 47, 47, 48, 49, 50, 51, 52, 53, 53, 54, 55, 57, 56, 57, 59, 59,
60, 60, 62, 63, 63, 65, 65, 65, 66, 67, 68, 69, 70, 71, 72, 72, 73, 74, 75, 76,
76, 78, 78, 79, 80, 81, 81, 82, 82, 83, 84, 84, 85, 87, 88, 89, 90, 91, 91, 92,
93, 94, 95, 96, 96, 97, 98, 99, 99, 100, 101, 101, 103, 103, 104, 105, 106, 107,
108, 108, 110, 110, 111, 112, 113, 114, 115, 114, 115, 116, 117, 118, 119, 119,
120, 118, 119, 119, 119, 119, 118, 118, 119, 118, 119, 119, 120, 120, 119, 119,
119, 120, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 120, 119, 119, 119, 119, 119, 120, 118, 119, 120, 119, 119, 119, 120, 119,
119, 120, 118, 119, 119, 120, 118, 119, 119, 119, 119, 119, 120, 119, 119, 120,
119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 118, 118, 119, 119, 119, 119,
119, 118, 119, 119, 118, 119, 118, 119, 119, 120, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 121, 118, 121, 115, 127, 6, -124, -116,
-121, -119, -119, -118, -120, -119, -119, -120, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119,
-119, -120, -120, -119, -120, -120, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -118, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119,
-119, -119, -120, -118, -119, -119, -119, -120, -119, -120, -119, -120, -119,
-118, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119,
-120, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -118, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -120,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119,
-119, -120, -119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -120, -119, -119, -119, -119,
-118, -120, -118, -119, -119, -120, -118, -120, -117, -121, -117, -121, -117,
-121, -117, -121, -117, -121, -115, -5, };