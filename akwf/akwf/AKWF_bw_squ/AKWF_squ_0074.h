#define DATA_LENGTH 512
#define DATA AKWF_squ_0074

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 14, 18, 23, 27, 32, 36, 41, 47,
50, 54, 60, 65, 69, 74, 78, 83, 87, 93, 97, 102, 106, 111, 116, 120, 120, 119,
119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120,
119, 118, 120, 120, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118,
118, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118,
119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 118, 119, 118, 118, 118, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 118, 118, 118, 120, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119,
120, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119,
119, 119, 119, 120, 119, 119, 120, 119, 118, 119, 120, 120, 119, 119, 119, 119,
118, 119, 120, 120, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 120, 120, 119, 118, 120, 118, 119, 119, 120, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 120,
119, 119, 119, 120, 119, 119, 120, 119, 120, 118, 120, 119, 119, 119, 120, 117,
122, 115, 127, 7, -123, -116, -121, -117, -120, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -119, -119, -120, -119, -120, -119,
-119, -118, -119, -120, -120, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -118,
-119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -120,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -118, -119, -120, -119, -118, -119, -119, -120, -118,
-118, -119, -119, -120, -119, -119, -119, -119, -118, -118, -119, -119, -119,
-119, -119, -118, -120, -119, -119, -118, -119, -119, -120, -119, -120, -119,
-120, -119, -118, -119, -119, -120, -119, -120, -119, -119, -120, -119, -120,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -118, -118, -119, -119, -120, -119, -119, -119, -119, -118, -120,
-119, -119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -120, -119, -119, -119, -120, -119, -118, -119,
-119, -118, -120, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -118, -120, -118, -120, -118, -121,
-118, -120, -117, -122, -117, -121, -117, -122, -117, -121, -114, -5, };