#define DATA_LENGTH 512
#define DATA AKWF_squ_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 123, 116, 122, 117,
121, 117, 121, 118, 120, 117, 119, 117, 120, 118, 120, 118, 119, 119, 119, 120,
119, 119, 119, 120, 118, 120, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119,
119, 119, 118, 119, 120, 119, 118, 119, 119, 119, 119, 120, 119, 119, 120, 119,
119, 119, 119, 119, 119, 118, 118, 119, 119, 118, 118, 119, 119, 119, 119, 119,
118, 119, 119, 119, 118, 119, 119, 118, 118, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 119, 120, 119, 119, 119, 120, 119, 120, 119, 120, 119, 119, 119, 119,
120, 119, 119, 119, 120, 118, 119, 118, 120, 118, 120, 118, 120, 118, 119, 117,
120, 118, 120, 118, 119, 119, 119, 119, 119, 119, 119, 120, 117, 122, 117, 123,
115, 126, 111, 127, 103, 127, 34, -128, -107, -127, -114, -122, -117, -121,
-118, -119, -119, -118, -120, -118, -121, -118, -120, -118, -120, -117, -119,
-119, -120, -118, -120, -118, -120, -119, -120, -119, -120, -118, -120, -118,
-120, -118, -120, -118, -120, -117, -120, -117, -121, -117, -121, -117, -122,
-117, -122, -92, 99, 127, 114, 124, 114, 123, 116, 122, 116, 122, 117, 121, 118,
121, 118, 120, 119, 119, 119, 118, 120, 118, 120, 118, 120, 118, 121, 118, 121,
118, 120, 117, 120, 118, 119, 119, 118, 120, 117, 124, 113, 127, 104, 127, -8,
-128, -104, -128, -111, -124, -115, -122, -118, -120, -119, -119, -119, -120,
-120, -118, -120, -118, -120, -118, -120, -118, -121, -118, -119, -118, -119,
-118, -120, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -120, -119, -120, -119, -119, -119, -118, -120, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -120,
-119, -119, -119, -119, -120, -119, -119, -120, -119, -118, -120, -119, -120,
-119, -120, -118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118,
-119, -120, -119, -119, -120, -120, -119, -119, -118, -119, -119, -120, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -120, -118, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -118, -120, -120, -118, -120, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -118, -119, -118, -119, -119, -120,
-119, -119, -118, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119,
-119, -120, -118, -120, -119, -120, -118, -120, -117, -122, -117, -122, -116,
-124, -114, -126, -101, };