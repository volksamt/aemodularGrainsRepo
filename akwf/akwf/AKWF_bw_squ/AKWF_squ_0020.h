#define DATA_LENGTH 512
#define DATA AKWF_squ_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {107, 123, 117, 121, 116, 123, -108,
-120, -121, -116, -125, -109, -128, -58, 127, 106, 126, 114, 122, 117, 121, 118,
119, 120, 119, 121, 117, 121, 118, 121, 117, 120, 117, 121, 117, 120, 118, 120,
118, 120, 119, 119, 118, 119, 118, 119, 120, 119, 120, 120, 120, 118, 120, 119,
119, 119, 119, 120, 119, 119, 120, 119, 120, 120, 119, 120, 119, 119, 119, 118,
119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 120, 118,
119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 120,
120, 120, 119, 119, 118, 120, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 118, 119, 118, 119, 118, 120, 119, 119, 118, 120, 119,
119, 119, 120, 119, 119, 119, 118, 120, 118, 119, 118, 122, 117, 124, 111, 127,
-72, -128, -105, -128, -104, -127, 89, 127, 117, 117, 123, 112, 127, 84, -128,
-112, -122, -117, -120, -119, -119, -120, -117, -120, -117, -121, -117, -121,
-118, -121, -118, -121, -118, -121, -118, -120, -119, -120, -118, -120, -119,
-120, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119,
-120, -119, -120, -119, -120, -119, -119, -119, -120, -118, -120, -119, -119,
-119, -118, -119, -120, -119, -119, -119, -118, -119, -119, -120, -119, -120,
-119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -118, -119,
-120, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -120, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -118, -119,
-118, -119, -119, -120, -119, -119, -119, -118, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -118, -120, -119, -119, -119, -120, -119, -120, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119,
-118, -119, -119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120,
-119, -120, -119, -118, -119, -119, -119, -120, -118, -119, -119, -119, -119,
-119, -118, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -120, -120, -119, -119, -119,
-119, -119, -119, -118, -120, -118, -120, -119, -119, -118, -119, -119, -120,
-118, -119, -119, -119, -119, -119, -120, -118, -119, -117, -121, -117, -121,
-117, -121, -117, -121, -116, -123, -114, -126, -102, };