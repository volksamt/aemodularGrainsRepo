#define DATA_LENGTH 512
#define DATA AKWF_squ_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 116, 123, 116, 121, 116,
121, 118, 121, 117, 121, 118, 120, 118, 120, 118, 119, 119, 119, 119, 119, 119,
119, 120, 119, 120, 119, 119, 119, 120, 119, 120, 119, 119, 119, 118, 118, 119,
119, 120, 119, 120, 118, 119, 120, 119, 120, 118, 120, 119, 118, 119, 118, 118,
119, 120, 119, 119, 120, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 120, 120, 119, 119, 119, 119, 120, 119, 118, 120, 119,
120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118, 119, 118,
118, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 118, 118,
119, 119, 120, 118, 119, 120, 119, 120, 118, 119, 120, 119, 120, 119, 120, 119,
119, 118, 119, 119, 120, 118, 118, 118, 119, 119, 119, 119, 119, 120, 120, 119,
118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 118, 119,
119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 118, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120, 120, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 118, 119, 120, 119,
119, 119, 119, 119, 120, 119, 118, 119, 118, 119, 119, 119, 119, 120, 119, 119,
120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 120, 119, 119, 118,
120, 119, 120, 118, 119, 119, 119, 119, 119, 120, 119, 120, 117, 120, 116, 121,
117, 122, 115, 123, 114, 124, 113, 127, 110, 127, 88, -127, -117, -119, -120,
-117, -122, -117, -122, -117, -122, -117, -122, -117, -121, -117, -121, -118,
-121, -118, -120, -118, -120, -119, -120, -118, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119,
-119, -119, -119, -120, -120, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -120, -120, -118, -120, -119, -120,
-120, -118, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -120, -120,
-119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -118, -119, -119,
-120, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -120, -118, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -118, -120, -118, -119, -118, -119, -119, -120, -119, -120,
-119, -120, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -120,
-118, -121, -117, -121, -117, -121, -117, -122, -116, -123, -114, -127, -101, };