#define DATA_LENGTH 512
#define DATA AKWF_squ_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 123, 116, 121, 117,
120, 117, 121, 118, 121, 118, 120, 118, 119, 118, 119, 119, 119, 119, 119, 120,
119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 120, 119, 119, 120, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 120, 118, 119, 119, 118, 119, 120, 118, 119, 119, 119, 119,
119, 120, 120, 119, 120, 118, 119, 119, 119, 118, 118, 119, 119, 120, 119, 119,
118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 118, 119, 118, 119, 119, 118, 118, 119, 119, 118, 119, 120, 118,
119, 119, 119, 118, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 120, 119, 120, 118, 120, 118, 120, 118, 119, 118, 120,
119, 120, 118, 118, 119, 119, 120, 117, 120, 116, 122, 116, 122, 116, 124, 114,
126, 112, 127, 107, 127, 69, -128, -113, -122, -118, -119, -119, -118, -120,
-117, -121, -116, -122, -117, -121, -118, -121, -118, -120, -117, -120, -118,
-119, -118, -120, -119, -120, -119, -119, -119, -119, -120, -119, -118, -118,
-120, -118, -119, -118, -119, -119, -119, -118, -119, -119, -120, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -120, -119, -119, -119, -120, -119, -119, -118, -119, -119,
-119, -119, -120, -120, -120, -118, -120, -119, -119, -120, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -118,
-119, -120, -119, -119, -119, -119, -120, -120, -119, -119, -120, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119,
-119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-120, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -118, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -118, -118, -119, -119, -120,
-120, -119, -119, -119, -119, -120, -120, -119, -118, -119, -119, -119, -120,
-118, -119, -119, -119, -120, -119, -119, -119, -119, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -118, -120,
-119, -119, -119, -119, -120, -119, -120, -120, -119, -119, -119, -118, -120,
-118, -121, -118, -122, -117, -121, -117, -122, -115, -123, -114, -126, -101, };