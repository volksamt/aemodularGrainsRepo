#define DATA_LENGTH 512
#define DATA AKWF_squ_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {26, 93, 119, 118, 120, 118, 119, 118,
119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 118, 118,
119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 118, 119, 120, 119, 119, 120,
119, 118, 119, 119, 120, 119, 118, 119, 118, 118, 119, 118, 118, 118, 119, 118,
119, 119, 118, 119, 118, 118, 119, 119, 119, 119, 118, 118, 118, 118, 118, 118,
118, 119, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
119, 117, 119, 116, 120, 47, -27, -25, -28, -26, -28, -25, -27, -27, -27, -27,
-27, -27, -27, -27, -26, -27, -26, -27, -27, -27, -26, -27, -26, -27, -26, -28,
-27, -27, -27, -26, -26, -27, -26, -27, -27, -26, -27, -27, -28, -27, -26, -27,
-27, -26, -27, -27, -27, -26, -27, -27, -27, -27, -27, -26, -26, -26, -27, -27,
-27, -27, -26, -26, -26, -28, -26, -27, -27, -27, -26, -27, -27, -28, -27, -26,
-26, -27, -27, -27, -27, -26, -27, -26, -27, -26, -26, -26, -27, -27, -26, -27,
-27, -26, -26, -27, -27, -27, -27, -27, -27, -27, -26, -27, -27, -27, -26, -27,
-26, -27, -27, -27, -27, -26, -26, -27, -26, -26, -26, -27, -27, -27, -26, -26,
-27, -27, -26, -27, -26, -26, -27, -27, -27, -27, -27, -26, -26, -26, -27, -27,
-27, -26, -26, -26, -26, -27, -27, -27, -27, -26, -27, -26, -26, -26, -26, -27,
-26, -26, -27, -26, -26, -26, -27, -27, -26, -27, -26, -26, -26, -27, -26, -27,
-26, -27, -27, -26, -27, -26, -27, -26, -26, -27, -26, -26, -27, -26, -26, -26,
-26, -26, -26, -26, -26, -26, -27, -27, -26, -27, -27, -27, -26, -26, -27, -27,
-26, -26, -27, -26, -26, -26, -26, -27, -26, -26, -26, -26, -27, -26, -26, -27,
-26, -26, -25, -26, -26, -27, -27, -27, -27, -26, -26, -26, -26, -26, -26, -26,
-26, -27, -26, -26, -27, -26, -26, -27, -26, -27, -26, -26, -26, -26, -26, -27,
-26, -26, -26, -26, -26, -26, -26, -27, -26, -26, -26, -26, -26, -26, -26, -27,
-26, -26, -26, -26, -26, -26, -26, -26, -26, -25, -26, -26, -27, -26, -26, -26,
-25, -25, -26, -25, -26, -25, -27, -26, -26, -26, -26, -26, -26, -25, -26, -26,
-26, -26, -26, -25, -25, -26, -26, -26, -26, -26, -25, -26, -26, -26, -25, -27,
-26, -26, -25, -26, -26, -26, -26, -26, -25, -25, -26, -26, -26, -26, -26, -25,
-26, -25, -26, -25, -27, -26, -26, -26, -26, -26, -25, -26, -26, -26, -26, -26,
-26, -26, -25, -26, -26, -25, -26, -26, -26, -25, -26, -26, -25, -26, -26, -27,
-25, -26, -26, -26, -26, -26, -26, -26, -26, -26, -26, -25, -26, -25, -25, -26,
-25, -25, -25, -26, -26, -26, -26, -26, -25, -26, -26, -26, -26, -26, -26, -26,
-25, -25, -25, -25, -26, -26, -25, -26, -26, -25, -26, -26, -26, -26, -26, -25,
-26, -25, -26, -25, -26, -25, -27, -20, };