#define DATA_LENGTH 512
#define DATA AKWF_squ_0081

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 7, 8, 10, 11, 12, 14, 16,
17, 18, 20, 20, 22, 24, 25, 26, 28, 29, 31, 32, 34, 35, 36, 38, 39, 41, 42, 43,
45, 46, 47, 49, 49, 52, 53, 54, 55, 57, 59, 60, 62, 63, 64, 65, 67, 68, 70, 71,
73, 74, 75, 77, 78, 80, 81, 82, 84, 85, 86, 88, 89, 91, 92, 94, 95, 96, 97, 99,
100, 102, 103, 104, 106, 107, 109, 109, 112, 112, 115, 116, 116, 119, 118, 120,
119, 120, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 120,
119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 120, 120, 118, 118, 120, 120,
119, 120, 119, 119, 120, 119, 119, 118, 118, 119, 119, 119, 119, 118, 119, 119,
119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 118, 119, 118, 118, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 120, 119, 119,
118, 120, 120, 120, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 120, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118,
119, 118, 118, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 118, 120,
119, 119, 118, 120, 117, 121, 115, 126, 8, -124, -116, -121, -117, -119, -118,
-120, -119, -119, -119, -119, -120, -119, -120, -119, -119, -118, -119, -119,
-120, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119,
-118, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -120,
-119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -118, -119, -120, -120, -120, -119, -119, -120, -119, -119, -119,
-119, -118, -119, -118, -119, -119, -118, -119, -119, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -118, -119, -120,
-118, -118, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119,
-119, -118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -120,
-119, -119, -118, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -120, -120, -120, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -120, -118, -120,
-119, -119, -120, -119, -118, -119, -120, -119, -119, -119, -120, -118, -120,
-118, -120, -118, -120, -118, -121, -117, -121, -117, -122, -117, -122, -117,
-122, -114, -4, };