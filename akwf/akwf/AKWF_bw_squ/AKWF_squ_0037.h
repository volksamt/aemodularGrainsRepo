#define DATA_LENGTH 512
#define DATA AKWF_squ_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 42, 96, 119, 118, 116, 116, 116,
114, 114, 113, 113, 112, 111, 111, 110, 109, 109, 108, 107, 107, 105, 105, 105,
105, 104, 103, 102, 103, 101, 101, 101, 100, 99, 99, 98, 97, 97, 96, 96, 95, 94,
94, 93, 92, 93, 92, 90, 90, 90, 89, 89, 89, 87, 88, 87, 86, 86, 85, 85, 84, 84,
83, 82, 82, 82, 81, 80, 80, 80, 79, 79, 78, 78, 78, 76, 76, 75, 75, 75, 74, 74,
72, 74, 72, 72, 71, 70, 71, 70, 69, 69, 61, 24, -32, -54, -52, -52, -51, -51,
-51, -52, -50, -51, -51, -50, -50, -49, -49, -49, -49, -49, -48, -48, -47, -48,
-47, -48, -47, -47, -46, -46, -46, -45, -46, -45, -45, -45, -45, -45, -44, -44,
-43, -43, -43, -42, -43, -43, -42, -42, -42, -42, -41, -41, -40, -41, -40, -40,
-40, -40, -40, -40, -40, -39, -39, -38, -39, -39, -38, -37, -37, -38, -37, -37,
-36, -37, -36, -36, -36, -36, -36, -35, -35, -35, -35, -35, -35, -35, -34, -34,
-34, -34, -34, -33, -34, -33, -34, -32, -33, -32, -33, -33, -32, -32, -31, -31,
-31, -31, -31, -30, -30, -30, -30, -30, -30, -29, -29, -29, -29, -29, -29, -28,
-28, -28, -28, -28, -28, -28, -27, -27, -27, -26, -27, -26, -26, -26, -27, -26,
-26, -26, -25, -26, -25, -25, -25, -26, -24, -25, -25, -24, -25, -24, -24, -24,
-23, -23, -23, -23, -23, -23, -22, -22, -22, -22, -23, -23, -22, -23, -22, -22,
-21, -22, -21, -21, -21, -21, -21, -20, -20, -20, -20, -20, -20, -19, -19, -20,
-19, -20, -19, -19, -19, -19, -19, -19, -18, -19, -18, -19, -18, -18, -17, -17,
-17, -18, -18, -17, -17, -17, -17, -17, -17, -17, -16, -17, -16, -15, -16, -16,
-17, -16, -16, -15, -16, -16, -16, -15, -15, -15, -14, -16, -15, -15, -14, -15,
-15, -14, -14, -15, -14, -14, -14, -13, -13, -14, -13, -14, -13, -13, -13, -14,
-14, -13, -13, -12, -13, -12, -12, -12, -12, -12, -12, -12, -12, -11, -12, -12,
-11, -12, -11, -12, -11, -11, -11, -11, -11, -11, -11, -11, -11, -10, -11, -11,
-10, -10, -10, -10, -10, -10, -9, -10, -9, -10, -10, -9, -9, -10, -9, -9, -8,
-9, -9, -9, -8, -9, -8, -8, -8, -8, -8, -8, -8, -8, -8, -9, -9, -8, -8, -8, -8,
-8, -7, -7, -8, -8, -8, -7, -7, -7, -7, -7, -7, -7, -6, -6, -7, -7, -7, -7, -6,
-6, -7, -6, -6, -6, -6, -6, -6, -7, -6, -6, -6, -6, -5, -6, -6, -6, -5, -6, -5,
-6, -6, -5, -5, -5, -5, -5, -5, -5, -4, -4, -5, -4, -5, -4, -4, -5, -4, -4, -4,
-5, -5, -4, -4, -5, -4, -4, -4, -4, -4, -3, -4, -3, -3, -4, -3, -4, -3, -3, -3,
-3, -3, -4, -3, -3, -4, -3, -3, -3, -3, -4, -3, -3, -3, -3, -2, -3, -2, -3, -2,
-2, -3, -2, };