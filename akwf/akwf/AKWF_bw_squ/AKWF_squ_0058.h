#define DATA_LENGTH 512
#define DATA AKWF_squ_0058

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1,
1, 0, 1, 1, 1, 1, 1, 0, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1,
1, 1, 1, 1, 1, 1, 0, 0, 1, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 1, 1,
1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 2, 1, 2, 0, 1, 1, 2, 1, 1, 1, 1, 2, 0, 2, 1, 0, 1,
1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 2, 2, 1, 0, 1, 1, 1, 1, 1, 0, 1, 1,
1, 2, 1, 2, 1, 0, 1, 1, 2, 2, 1, 1, 1, 1, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1,
1, 1, 1, 2, 1, 1, 1, 2, 2, 1, 1, 2, 1, 1, 2, 2, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0,
2, 1, 1, 1, 2, 2, 1, 2, 2, 2, 1, 2, 1, 1, 1, 2, 1, 1, 1, 2, 0, 3, -2, 34, 99,
108, 110, 112, 113, 115, 116, 118, 117, 119, 115, 88, 37, 13, 12, 10, 10, 8, 7,
6, 6, 6, 4, 3, 3, 2, 2, 0, 0, -1, -1, -2, -2, -3, -3, -4, -4, -5, -5, -5, -6,
-6, -7, -7, -7, -7, -8, -8, -8, -8, -9, -10, -9, -9, -9, -10, -9, -10, -11, -11,
-11, -10, -11, -11, -12, -11, -11, -11, -12, -11, -11, -12, -12, -11, -12, -11,
-12, -11, -13, -12, -12, -11, -12, -12, -12, -12, -12, -11, -12, -12, -12, -12,
-12, -12, -12, -11, -12, -12, -12, -12, -11, -12, -12, -11, -12, -11, -12, -11,
-11, -10, -11, -10, -10, -11, -10, -10, -11, -11, -10, -10, -11, -9, -11, -11,
-10, -11, -10, -9, -9, -10, -9, -9, -10, -9, -9, -9, -9, -9, -9, -8, -10, -9,
-8, -9, -9, -8, -8, -8, -8, -8, -8, -9, -7, -8, -8, -7, -7, -7, -8, -7, -7, -7,
-7, -8, -7, -7, -7, -6, -6, -7, -7, -7, -6, -6, -6, -6, -6, -6, -6, -7, -6, -6,
-6, -6, -5, -6, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -4, -4, -4, -5,
-4, -4, -4, -4, -3, -5, -4, -4, -4, -4, -3, -3, -3, -4, -4, -3, -3, -3, -3, -3,
-3, -3, -3, -3, -3, -4, -3, -2, -3, -3, -2, -2, -3, -3, -3, -3, -2, -3, -2, -2,
-2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -1, -1,
-2, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1,
0, -1, -1, -1, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, -1, 0,
0, 1, 0, 0, 0, 0, 0, };