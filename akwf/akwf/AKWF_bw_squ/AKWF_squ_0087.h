#define DATA_LENGTH 512
#define DATA AKWF_squ_0087

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 2, 4, 4, 6, 6, 7, 8, 8, 9, 11,
11, 12, 13, 14, 15, 15, 16, 18, 18, 19, 20, 21, 22, 23, 24, 24, 25, 26, 27, 27,
28, 30, 30, 31, 32, 33, 34, 35, 36, 36, 37, 38, 39, 40, 41, 41, 43, 44, 45, 45,
46, 47, 47, 49, 49, 50, 51, 52, 53, 54, 55, 56, 56, 58, 58, 60, 61, 61, 62, 62,
64, 65, 66, 66, 68, 68, 68, 69, 71, 71, 73, 73, 74, 74, 76, 76, 77, 79, 79, 81,
81, 82, 82, 84, 84, 85, 86, 87, 88, 89, 90, 90, 92, 93, 93, 93, 96, 96, 97, 97,
98, 99, 100, 101, 102, 103, 104, 105, 105, 106, 107, 108, 109, 110, 110, 112,
113, 113, 115, 115, 116, 117, 118, 118, 119, 119, 119, 119, 119, 118, 119, 119,
119, 120, 118, 119, 119, 120, 119, 120, 119, 120, 119, 119, 119, 119, 120, 118,
119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118,
119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 118, 119, 118, 119, 118, 120,
119, 119, 119, 119, 119, 119, 119, 118, 120, 118, 119, 117, 121, 115, 126, 7,
-124, -116, -121, -118, -120, -118, -120, -118, -119, -119, -119, -119, -119,
-119, -119, -120, -118, -119, -119, -120, -119, -120, -119, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-120, -119, -119, -119, -119, -120, -119, -118, -119, -120, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -118, -119, -119, -120, -119, -119, -119, -118, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -120, -118, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -118, -120, -120, -120, -119, -118,
-120, -119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-120, -120, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -118, -118, -119, -119, -118, -119, -119,
-119, -119, -119, -120, -119, -119, -120, -119, -120, -118, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -118,
-120, -119, -118, -119, -120, -120, -119, -119, -119, -119, -118, -119, -119,
-120, -120, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -120, -118, -119, -120,
-119, -120, -118, -120, -118, -119, -118, -120, -118, -121, -118, -120, -117,
-122, -117, -120, -117, -121, -116, -122, -115, -5, };