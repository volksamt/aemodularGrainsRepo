#define DATA_LENGTH 512
#define DATA AKWF_squ_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 115, 123, 116, 123, 117,
121, 117, 121, 117, 120, 118, 120, 118, 119, 118, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120,
118, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118,
120, 120, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 118, 118, 118,
118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118,
120, 119, 119, 120, 119, 118, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 120, 120, 120,
120, 119, 119, 119, 118, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 120, 119, 118, 119, 119, 119, 120, 119, 119,
120, 119, 120, 119, 120, 120, 120, 119, 120, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 118, 119, 118, 119, 119, 120,
118, 120, 118, 119, 118, 120, 118, 120, 119, 119, 119, 119, 120, 118, 120, 117,
121, 116, 122, 116, 124, 113, 126, 111, 127, 106, 127, 63, -128, -111, -124,
-117, -120, -119, -118, -120, -118, -121, -117, -121, -118, -121, -116, -121,
-117, -121, -117, -121, -118, -120, -118, -120, -118, -120, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -118, -120, -119, -120, -119, -119, -118,
-119, -118, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119,
-118, -119, -119, -118, -119, -119, -118, -120, -119, -119, -118, -120, -119,
-120, -119, -119, -119, -118, -119, -119, -119, -118, -118, -119, -119, -120,
-119, -120, -119, -119, -119, -120, -118, -119, -118, -118, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -120, -119, -119, -119, -120, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -118, -119, -118, -118, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -118,
-118, -120, -119, -119, -118, -119, -119, -119, -119, -119, -118, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -118, -120, -119,
-119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120,
-119, -120, -119, -119, -119, -119, -120, -119, -120, -119, -119, -120, -120,
-119, -119, -119, -119, -119, -120, -119, -120, -119, -120, -119, -119, -119,
-120, -118, -119, -119, -119, -119, -118, -120, -118, -120, -118, -120, -118,
-120, -118, -120, -117, -121, -116, -123, -116, -123, -113, -126, -102, };