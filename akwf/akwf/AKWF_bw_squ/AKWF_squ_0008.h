#define DATA_LENGTH 512
#define DATA AKWF_squ_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 116, 122, 116, 122, 117,
121, 117, 121, 117, 120, 119, 120, 118, 120, 119, 120, 118, 120, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 120, 119,
119, 119, 120, 119, 119, 120, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 118, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 120, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 120, 120,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120,
120, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119,
119, 118, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 118, 120, 118, 120, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 120, 120, 118, 119, 119, 119, 120, 120, 119, 119, 119,
119, 120, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 118, 119, 119, 119, 119, 120, 119, 120, 119, 119, 118, 120, 118, 120,
118, 120, 118, 119, 119, 120, 119, 119, 120, 119, 120, 118, 120, 117, 121, 116,
123, 116, 123, 113, 125, 112, 127, 108, 127, 76, -128, -114, -121, -119, -118,
-121, -117, -122, -117, -120, -117, -121, -117, -121, -116, -121, -117, -121,
-117, -121, -118, -120, -118, -119, -119, -119, -119, -118, -119, -119, -119,
-120, -119, -119, -120, -119, -120, -118, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -120, -119, -119,
-120, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-120, -118, -119, -119, -120, -119, -120, -118, -119, -119, -119, -119, -119,
-118, -119, -119, -120, -119, -119, -119, -119, -118, -119, -120, -120, -120,
-119, -120, -120, -120, -120, -119, -119, -119, -120, -120, -120, -118, -120,
-120, -120, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119,
-120, -119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -118, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -120, -119, -120, -119, -119, -119, -119, -120, -119, -120, -119, -120,
-119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120,
-120, -119, -119, -119, -118, -120, -119, -119, -119, -119, -120, -120, -119,
-119, -119, -118, -120, -118, -119, -119, -118, -119, -119, -119, -119, -118,
-120, -119, -120, -119, -119, -119, -119, -118, -120, -120, -119, -119, -118,
-120, -118, -119, -118, -120, -117, -120, -117, -121, -117, -122, -116, -123,
-114, -127, -101, };