#define DATA_LENGTH 512
#define DATA AKWF_squ_0072

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 14, 28, 41, 56, 70, 84, 97, 113,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 120, 119, 119,
119, 119, 119, 120, 119, 119, 118, 120, 120, 118, 119, 119, 119, 119, 120, 119,
120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
120, 119, 119, 120, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 120, 119, 119, 119, 119, 119,
120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
118, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 118, 119,
118, 119, 120, 119, 120, 120, 119, 118, 120, 120, 119, 119, 119, 119, 119, 119,
118, 120, 119, 120, 119, 120, 119, 120, 118, 120, 118, 119, 118, 119, 118, 120,
119, 119, 120, 118, 121, 117, 120, -19, -128, -115, -121, -117, -121, -119,
-120, -118, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -120, -118, -119, -119, -120, -119, -119, -119, -119, -120, -118,
-119, -120, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -118, -120, -119, -120, -119,
-119, -119, -119, -119, -119, -120, -120, -119, -118, -119, -120, -118, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-120, -119, -119, -118, -119, -119, -118, -119, -119, -119, -120, -119, -119,
-119, -119, -118, -119, -120, -119, -119, -120, -119, -119, -119, -118, -119,
-119, -120, -119, -118, -120, -119, -120, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -120, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119,
-119, -120, -118, -119, -120, -119, -120, -119, -119, -120, -120, -119, -119,
-120, -119, -119, -119, -119, -120, -119, -120, -119, -118, -120, -119, -119,
-118, -119, -119, -119, -120, -119, -118, -118, -119, -119, -119, -119, -120,
-118, -119, -118, -121, -118, -120, -117, -122, -117, -122, -115, -123, -114,
-126, -101, };