#define DATA_LENGTH 512
#define DATA AKWF_squ_0092

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 3, 3, 5, 6, 6, 6, 7, 8, 8,
10, 10, 10, 12, 12, 12, 13, 13, 15, 15, 16, 16, 18, 18, 19, 19, 20, 21, 21, 22,
23, 23, 24, 24, 26, 26, 27, 28, 27, 29, 29, 31, 31, 31, 32, 33, 33, 33, 35, 34,
36, 37, 37, 38, 39, 39, 40, 41, 42, 42, 42, 44, 44, 44, 46, 46, 47, 47, 48, 48,
49, 49, 50, 51, 52, 52, 54, 54, 55, 54, 56, 56, 57, 58, 58, 59, 60, 61, 62, 62,
62, 63, 64, 65, 65, 65, 66, 67, 68, 68, 69, 70, 71, 71, 72, 73, 73, 73, 75, 75,
76, 76, 77, 78, 79, 79, 80, 81, 80, 82, 82, 82, 83, 85, 84, 85, 86, 87, 88, 88,
88, 89, 90, 91, 91, 93, 93, 93, 94, 95, 96, 97, 97, 98, 99, 99, 100, 101, 101,
102, 103, 102, 104, 104, 105, 105, 106, 107, 107, 108, 108, 109, 110, 112, 111,
112, 113, 114, 115, 114, 115, 116, 118, 118, 118, 118, 119, 119, 120, 119, 120,
119, 119, 120, 118, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 120, 120, 119, 119, 120, 120, 119, 119, 119, 119, 118, 119,
119, 119, 119, 120, 119, 120, 119, 120, 118, 120, 119, 119, 119, 120, 119, 118,
120, 119, 121, 117, 122, 115, 126, 7, -123, -117, -121, -118, -119, -118, -119,
-119, -118, -119, -119, -120, -119, -119, -118, -120, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119,
-118, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119, -118, -119,
-119, -119, -120, -118, -120, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -120, -120, -119, -118, -120, -120, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -118, -120, -119, -118, -119, -119, -118, -120,
-119, -118, -120, -119, -119, -120, -118, -119, -120, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -118, -118, -119, -120, -119, -119, -118, -119, -119, -119, -120, -119,
-119, -118, -119, -119, -119, -119, -120, -118, -118, -119, -118, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -120, -120, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -118, -119,
-119, -118, -119, -119, -118, -119, -120, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -118, -119, -120, -119, -119, -120, -119, -119, -120, -118, -120, -119,
-119, -119, -119, -120, -119, -119, -118, -119, -118, -119, -119, -120, -119,
-120, -118, -120, -117, -121, -117, -121, -117, -120, -117, -121, -117, -121,
-115, -4, };