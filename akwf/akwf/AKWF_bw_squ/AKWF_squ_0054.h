#define DATA_LENGTH 512
#define DATA AKWF_squ_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 1, 1, 1, 2, 2, 3, 3, 4, 3,
4, 4, 4, 4, 4, 4, 5, 5, 5, 5, 6, 6, 6, 7, 7, 7, 8, 7, 8, 9, 8, 9, 8, 8, 9, 10,
9, 11, 9, 11, 9, 27, 79, 92, 92, 96, 96, 98, 98, 100, 100, 102, 102, 104, 104,
105, 106, 106, 107, 107, 107, 108, 108, 109, 109, 108, 110, 110, 110, 110, 110,
109, 109, 109, 108, 108, 109, 109, 109, 108, 108, 108, 107, 106, 106, 105, 105,
105, 105, 105, 104, 103, 103, 102, 101, 101, 100, 99, 99, 99, 98, 97, 96, 96,
95, 95, 94, 92, 91, 92, 90, 90, 89, 88, 88, 87, 87, 86, 85, 83, 84, 82, 82, 80,
80, 79, 79, 78, 78, 77, 76, 75, 74, 72, 72, 72, 71, 70, 69, 68, 67, 66, 66, 65,
64, 64, 62, 63, 62, 61, 60, 59, 58, 57, 58, 56, 55, 54, 54, 53, 52, 52, 51, 50,
49, 49, 48, 47, 47, 46, 45, 44, 44, 43, 42, 41, 41, 41, 40, 39, 38, 37, 37, 37,
35, 35, 35, 34, 33, 33, 32, 32, 30, 30, 30, 29, 29, 28, 28, 27, 26, 25, 25, 24,
23, 22, 23, 22, 22, 22, 20, 20, 19, 19, 18, 18, 17, 16, 15, 16, 15, 15, 14, 14,
13, 13, 12, 11, 11, 12, 10, 10, 10, 9, 9, 9, 8, 7, 6, 6, 6, 6, 5, 5, 5, 4, 4, 3,
3, 3, 3, 2, 2, 1, 1, 0, 1, 0, 0, -1, -2, -1, -1, -3, -3, -3, -3, -3, -3, -4, -5,
-5, -5, -5, -6, -6, -7, -6, -7, -7, -7, -7, -7, -8, -9, -8, -9, -9, -9, -10,
-10, -10, -11, -19, -51, -92, -108, -109, -110, -112, -112, -114, -114, -116,
-116, -116, -118, -117, -118, -118, -118, -119, -120, -119, -119, -119, -119,
-119, -118, -119, -118, -118, -118, -118, -117, -117, -116, -116, -116, -115,
-115, -115, -114, -113, -112, -112, -111, -110, -109, -109, -108, -108, -107,
-106, -105, -104, -104, -102, -102, -102, -101, -99, -99, -98, -97, -96, -96,
-95, -94, -93, -92, -91, -90, -89, -89, -87, -86, -86, -84, -85, -83, -82, -81,
-81, -80, -78, -78, -76, -75, -74, -75, -74, -73, -71, -71, -70, -69, -68, -68,
-66, -65, -65, -64, -63, -63, -61, -61, -60, -59, -58, -58, -56, -55, -55, -54,
-54, -52, -52, -52, -50, -49, -48, -48, -48, -47, -45, -45, -44, -44, -43, -43,
-42, -41, -41, -40, -38, -39, -37, -38, -37, -36, -35, -34, -34, -34, -33, -32,
-32, -31, -30, -29, -30, -29, -28, -27, -27, -27, -25, -24, -24, -24, -23, -23,
-22, -22, -21, -20, -20, -20, -19, -20, -17, -17, -17, -16, -17, -16, -15, -15,
-14, -14, -14, -14, -12, -12, -12, -12, -11, -11, -10, -9, -10, -9, -8, -8, -8,
-8, -7, -7, -6, -7, -6, -6, -5, -4, -5, -4, -5, -3, -3, -2, -2, -2, -2, -2, -1,
-1, -1, 0, };