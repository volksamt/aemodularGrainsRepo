#define DATA_LENGTH 512
#define DATA AKWF_squ_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {27, 89, 118, 119, 116, 116, 116, 114,
114, 113, 112, 112, 112, 111, 110, 110, 109, 109, 108, 107, 107, 106, 106, 105,
105, 104, 104, 103, 102, 102, 101, 101, 100, 100, 99, 98, 98, 98, 97, 97, 96,
95, 95, 94, 94, 93, 92, 91, 91, 91, 91, 89, 89, 89, 88, 88, 87, 87, 86, 85, 85,
85, 85, 83, 83, 83, 83, 82, 82, 82, 80, 80, 79, 79, 78, 79, 77, 77, 77, 76, 77,
76, 75, 75, 74, 73, 73, 72, 72, 71, 72, 70, 71, 70, 71, 69, 68, 69, 69, 68, 67,
66, 67, 66, 65, 65, 64, 64, 64, 64, 63, 63, 62, 61, 62, 61, 61, 61, 61, 60, 59,
59, 59, 58, 58, 57, 58, 57, 56, 56, 56, 56, 55, 55, 54, 55, 53, 53, 53, 53, 53,
52, 51, 51, 51, 51, 50, 50, 50, 49, 49, 48, 48, 48, 48, 47, 47, 46, 47, 46, 45,
46, 45, 45, 44, 43, 43, 43, 43, 43, 43, 42, 42, 41, 41, 40, 41, 40, 40, 40, 40,
40, 39, 39, 38, 38, 38, 38, 38, 36, 38, 37, 37, 37, 36, 36, 35, 34, 35, 35, 34,
34, 35, 34, 33, 32, 32, 33, 32, 31, 31, 31, 31, 31, 32, 31, 30, 30, 30, 24, -15,
-76, -104, -103, -102, -102, -102, -100, -101, -100, -100, -99, -98, -98, -97,
-96, -97, -96, -95, -94, -94, -94, -94, -94, -93, -92, -92, -91, -91, -90, -89,
-89, -88, -88, -88, -88, -86, -86, -86, -85, -84, -84, -84, -84, -83, -82, -81,
-81, -81, -81, -80, -79, -80, -79, -78, -78, -78, -77, -77, -77, -77, -76, -75,
-75, -74, -73, -73, -73, -72, -72, -72, -72, -70, -70, -70, -70, -70, -70, -68,
-68, -67, -67, -67, -67, -66, -65, -65, -66, -64, -65, -64, -64, -63, -63, -63,
-62, -62, -62, -61, -61, -60, -60, -59, -60, -60, -59, -59, -58, -58, -58, -56,
-57, -56, -56, -56, -55, -55, -55, -54, -54, -54, -53, -53, -52, -53, -52, -52,
-52, -52, -51, -51, -49, -49, -49, -49, -48, -49, -48, -48, -48, -48, -47, -47,
-46, -46, -46, -45, -45, -45, -46, -45, -44, -43, -44, -43, -43, -43, -42, -43,
-42, -41, -42, -41, -41, -41, -40, -40, -40, -39, -39, -39, -38, -39, -38, -39,
-37, -38, -37, -38, -37, -36, -36, -36, -36, -35, -36, -34, -34, -34, -35, -35,
-34, -34, -34, -34, -33, -32, -33, -32, -32, -32, -31, -31, -32, -31, -30, -30,
-31, -30, -30, -30, -30, -29, -29, -28, -29, -29, -29, -28, -28, -27, -27, -26,
-27, -27, -27, -26, -27, -26, -26, -26, -26, -25, -25, -24, -25, -25, -24, -24,
-23, -23, -24, -23, -23, -22, -23, -23, -22, -22, -22, -22, -22, -21, -21, -20,
-21, -20, -20, -20, -20, -20, -19, -20, -20, -19, -18, -19, -19, -19, -19, -19,
-19, -18, -18, -18, -18, -17, -18, -18, -18, -17, -17, -16, -17, -16, -16, -16,
-15, -15, -15, -16, -9, };