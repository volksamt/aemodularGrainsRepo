#define DATA_LENGTH 512
#define DATA AKWF_squ_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {40, 53, 50, 53, 51, 53, 50, 52, 50,
52, 51, 52, 50, 52, 51, 51, 52, 52, 51, 51, 51, 51, 51, 51, 52, 52, 52, 51, 51,
51, 51, 51, 51, 51, 51, 51, 51, 52, 52, 51, 52, 51, 51, 51, 52, 52, 51, 52, 51,
51, 51, 52, 52, 52, 52, 51, 51, 52, 51, 52, 52, 52, 51, 51, 52, 52, 51, 52, 51,
52, 51, 51, 50, 51, 51, 51, 51, 52, 52, 50, 51, 51, 51, 51, 51, 51, 51, 51, 51,
51, 51, 52, 51, 50, 52, 51, 51, 51, 51, 52, 51, 51, 51, 51, 51, 50, 51, 51, 51,
51, 51, 51, 52, 52, 51, 51, 51, 52, 50, 50, 50, 51, 51, 51, 51, 51, 51, 51, 50,
51, 51, 50, 51, 51, 51, 52, 51, 50, 50, 51, 51, 50, 50, 51, 50, 51, 51, 50, 50,
51, 50, 51, 50, 51, 50, 50, 50, 50, 51, 51, 51, 51, 51, 51, 51, 51, 50, 50, 51,
51, 51, 50, 50, 50, 51, 50, 51, 50, 51, 50, 50, 50, 50, 51, 51, 50, 51, 50, 51,
51, 50, 50, 51, 51, 50, 50, 50, 51, 51, 50, 51, 51, 50, 50, 50, 51, 50, 50, 50,
51, 50, 51, 50, 50, 50, 50, 50, 50, 50, 50, 51, 50, 50, 50, 50, 50, 49, 50, 50,
50, 50, 50, 50, 51, 50, 50, 50, 50, 50, 50, 50, 50, 51, 50, 50, 50, 49, 50, 50,
50, 51, 49, 50, 50, 50, 49, 50, 50, 50, 50, 49, 50, 51, 50, 50, 50, 50, 50, 49,
50, 50, 50, 50, 49, 50, 49, 50, 50, 50, 50, 50, 50, 49, 49, 50, 49, 50, 50, 50,
50, 50, 50, 49, 49, 49, 50, 49, 49, 50, 50, 49, 51, 49, 49, 49, 49, 50, 50, 49,
50, 49, 49, 49, 50, 49, 49, 50, 49, 49, 50, 50, 49, 50, 50, 49, 50, 50, 49, 50,
50, 49, 50, 49, 49, 49, 49, 50, 50, 50, 49, 50, 49, 50, 49, 50, 48, 50, 48, 50,
49, 50, 49, 49, 49, 49, 51, 48, 42, -73, -126, -114, -122, -116, -121, -118,
-120, -118, -120, -118, -120, -118, -119, -119, -120, -119, -119, -118, -119,
-119, -118, -119, -119, -119, -118, -119, -119, -120, -118, -120, -119, -119,
-119, -118, -119, -119, -118, -119, -119, -119, -119, -119, -118, -118, -119,
-118, -118, -118, -119, -118, -119, -118, -118, -118, -119, -118, -119, -118,
-118, -118, -119, -118, -118, -118, -119, -118, -119, -118, -119, -118, -118,
-119, -118, -118, -119, -118, -118, -118, -119, -119, -118, -118, -118, -118,
-118, -119, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117,
-118, -118, -118, -118, -117, -118, -118, -117, -117, -118, -118, -119, -118,
-117, -118, -118, -118, -118, -118, -118, -117, -118, -118, -117, -117, -117,
-117, -118, -117, -117, -118, -117, -118, -118, -117, -118, -117, -118, -117,
-118, -117, -117, -117, -117, -117, -118, -117, -118, -116, -117, -116, -119,
-115, -121, -80, -6, };