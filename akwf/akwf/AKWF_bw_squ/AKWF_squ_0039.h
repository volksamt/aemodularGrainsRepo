#define DATA_LENGTH 512
#define DATA AKWF_squ_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 32, 87, 117, 119, 116, 116, 115,
115, 114, 114, 113, 112, 111, 111, 109, 109, 109, 108, 107, 107, 107, 106, 105,
104, 103, 104, 103, 102, 101, 101, 100, 100, 100, 98, 97, 98, 96, 97, 95, 95,
95, 94, 94, 92, 92, 91, 91, 90, 90, 89, 88, 88, 87, 87, 87, 87, 86, 86, 85, 84,
84, 84, 82, 82, 81, 81, 80, 80, 79, 79, 79, 77, 77, 77, 77, 76, 75, 76, 75, 74,
74, 73, 73, 69, 37, -19, -49, -49, -49, -48, -47, -48, -48, -47, -47, -46, -46,
-46, -46, -46, -46, -46, -45, -44, -44, -45, -44, -43, -44, -43, -43, -43, -43,
-42, -42, -42, -42, -42, -42, -41, -41, -41, -41, -40, -41, -40, -40, -40, -39,
-39, -40, -39, -39, -39, -39, -37, -37, -38, -38, -37, -37, -37, -37, -37, -37,
-36, -36, -36, -36, -35, -35, -35, -35, -34, -35, -35, -34, -34, -34, -33, -33,
-34, -33, -32, -32, -32, -32, -32, -32, -31, -31, -32, -32, -32, -31, -30, -30,
-31, -29, -30, -31, -30, -29, -29, -29, -28, -29, -29, -29, -28, -29, -29, -28,
-29, -28, -28, -27, -27, -27, -27, -26, -27, -27, -26, -26, -26, -26, -26, -26,
-26, -26, -26, -25, -25, -25, -25, -24, -24, -24, -24, -23, -23, -24, -24, -24,
-24, -23, -23, -23, -24, -22, -22, -23, -23, -23, -22, -22, -23, -22, -21, -21,
-21, -21, -21, -21, -21, -21, -21, -20, -20, -21, -20, -19, -20, -20, -20, -19,
-19, -19, -19, -19, -20, -19, -18, -19, -19, -19, -19, -17, -18, -18, -18, -17,
-18, -17, -17, -17, -17, -17, -17, -17, -16, -17, -17, -17, -17, -17, -16, -16,
-15, -16, -16, -15, -15, -16, -15, -15, -15, -15, -14, -15, -15, -14, -15, -15,
-14, -14, -15, -14, -14, -13, -14, -13, -14, -13, -13, -13, -12, -14, -12, -13,
-13, -13, -12, -12, -12, -12, -12, -13, -12, -12, -12, -12, -12, -11, -11, -11,
-11, -11, -12, -12, -11, -11, -10, -11, -11, -11, -10, -11, -10, -11, -10, -10,
-10, -11, -10, -10, -10, -9, -10, -10, -10, -9, -9, -9, -10, -9, -9, -9, -9, -9,
-9, -10, -9, -9, -9, -9, -8, -9, -8, -9, -8, -9, -8, -8, -9, -8, -8, -8, -8, -8,
-7, -7, -7, -7, -7, -8, -7, -8, -8, -7, -7, -7, -7, -8, -7, -7, -7, -6, -7, -7,
-7, -6, -6, -6, -6, -7, -6, -6, -5, -6, -6, -5, -6, -6, -6, -6, -6, -6, -6, -6,
-6, -5, -5, -5, -6, -6, -5, -5, -5, -4, -5, -5, -5, -6, -5, -5, -5, -5, -4, -4,
-4, -4, -5, -4, -4, -4, -4, -4, -4, -4, -4, -3, -4, -4, -3, -4, -4, -4, -3, -4,
-4, -3, -4, -4, -3, -3, -3, -3, -3, -3, -4, -4, -3, -3, -3, -3, -2, -3, -4, -3,
-3, -3, -2, -2, -3, -3, -2, -2, -2, -3, -2, -3, -2, -2, -2, -2, -2, -2, -2, -2,
};