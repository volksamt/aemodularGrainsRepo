#define DATA_LENGTH 512
#define DATA AKWF_squ_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 61, 127, 84, 5, -3, -1, -1, -1, -2,
-2, -2, -1, -2, -2, -2, -1, -2, -1, -1, -1, -1, -2, -1, -2, -1, -1, -2, -1, -1,
-2, -1, -2, -2, -2, -1, -2, -1, -1, -1, -1, -1, -2, -2, -1, -2, -1, -2, -2, -1,
-1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -2, -2,
-2, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -2, -1, 0, 0, -2, -1, -1, -1, -1,
-1, -2, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -2,
-1, 0, 0, -1, -1, -1, -1, -1, -1, -1, -2, -1, -2, -1, 0, -1, -1, -1, -1, -1, -1,
-1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, -1, -1, -1, -1, 0, -1, -1, -1, -1,
-1, -1, -1, -1, 0, 0, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0, -1, -1, 0, 0, 0, -1,
0, -1, 0, -1, 0, 0, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, 0, -1, -1, -1, 0, 0,
0, -1, 0, -1, -1, -1, -1, -1, 0, -1, -1, 0, 0, -1, 0, 0, 0, -1, 0, -1, 0, -1,
-1, -1, 0, -1, 0, 0, -1, -1, -1, 0, 0, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0, -1,
-1, -1, 0, -1, 0, 0, -1, 0, -1, 0, 0, -1, 0, 0, -1, -1, -1, 0, 0, -1, -1, -1,
-1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, -1, 0, -1, 0, -1, 0, -1, -1, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1,
-1, 0, -1, 0, 0, -1, 0, 0, -1, -1, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, -1, 0,
0, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1,
0, 0, 1, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
0, 0, -1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, -1, 1, 0, -1, 0, -1,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 1, -1, -1, 0, -1, 0, -1,
0, -1, -1, 0, 0, 1, 0, 0, 1, 1, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, -1, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 1,
0, 0, 0, 0, };