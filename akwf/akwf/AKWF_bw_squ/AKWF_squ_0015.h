#define DATA_LENGTH 512
#define DATA AKWF_squ_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 32, 34, 34, 34, 34, 36, 35, 37, 37,
37, 38, 38, 38, 39, 39, 41, 40, 41, 41, 42, 42, 43, 44, 44, 44, 46, 46, 46, 47,
47, 48, 49, 49, 48, 49, 50, 50, 50, 51, 52, 52, 53, 54, 53, 54, 55, 55, 55, 57,
57, 57, 58, 59, 59, 59, 59, 60, 60, 61, 62, 61, 62, 63, 64, 64, 65, 65, 65, 66,
66, 67, 67, 67, 68, 68, 69, 70, 70, 71, 71, 72, 72, 72, 73, 74, 73, 74, 75, 75,
76, 76, 77, 78, 78, 79, 79, 79, 80, 80, 81, 82, 82, 83, 83, 83, 84, 84, 85, 86,
86, 86, 87, 88, 88, 87, 88, 88, 90, 89, 91, 91, 91, 91, 92, 92, 93, 94, 94, 95,
96, 96, 97, 97, 97, 98, 98, 99, 99, 100, 100, 101, 101, 101, 102, 102, 103, 103,
104, 105, 106, 106, 106, 106, 107, 107, 108, 108, 108, 110, 110, 110, 111, 111,
112, 113, 113, 113, 114, 114, 115, 114, 116, 116, 117, 117, 118, 118, 119, 119,
120, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 118, 119, 120, 119, 119,
118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 120, 119,
119, 119, 118, 118, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
120, 118, 119, 119, 119, 118, 119, 118, 119, 118, 120, 118, 119, 119, 119, 118,
119, 119, 120, 119, 119, 119, 118, 119, 118, 121, 117, 120, -19, -128, -114,
-121, -117, -121, -117, -120, -118, -120, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -120, -119, -119, -118, -120,
-119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -120, -119, -120,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -118, -119, -119, -119, -119, -119, -118, -119, -120, -119, -119, -120,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -120, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -120, -119, -119, -118, -120, -119, -119,
-119, -118, -119, -119, -118, -118, -119, -120, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -120, -120, -120, -120, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -118, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119,
-120, -118, -119, -118, -120, -119, -120, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119, -118, -120,
-118, -120, -119, -120, -118, -119, -118, -120, -119, -118, -119, -119, -119,
-119, -119, -118, -120, -118, -121, -118, -121, -117, -121, -117, -122, -116,
-122, -116, -124, -113, -127, -101, };