#define DATA_LENGTH 512
#define DATA AKWF_squ_0082

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 6, 7, 9, 10, 11, 12, 14,
14, 16, 18, 19, 20, 21, 23, 24, 25, 26, 28, 29, 30, 32, 33, 35, 35, 37, 38, 40,
40, 42, 43, 44, 46, 47, 49, 50, 51, 51, 53, 54, 56, 57, 58, 59, 61, 62, 63, 64,
66, 67, 68, 69, 70, 71, 73, 75, 76, 77, 78, 80, 81, 82, 83, 84, 86, 88, 88, 90,
91, 92, 94, 95, 96, 97, 99, 99, 101, 103, 104, 106, 106, 108, 109, 111, 111,
113, 114, 115, 117, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 118, 119, 119,
120, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 118, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119,
120, 119, 119, 119, 118, 119, 119, 120, 120, 119, 119, 119, 118, 119, 119, 119,
120, 119, 119, 119, 119, 120, 118, 120, 119, 119, 119, 120, 118, 119, 119, 119,
118, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 120, 119, 120, 119, 118,
120, 118, 120, 118, 122, 115, 126, 8, -124, -117, -121, -118, -120, -118, -119,
-119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -120, -118, -119, -119, -119, -120, -120, -119, -118,
-118, -119, -120, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -120, -118,
-119, -119, -118, -119, -119, -118, -119, -119, -120, -118, -120, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -118, -120, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118, -120, -120,
-119, -119, -119, -120, -119, -119, -118, -119, -119, -119, -120, -119, -119,
-120, -118, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -118, -119, -119, -119, -120, -119, -120, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -118, -119,
-118, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -120, -119, -120, -119, -119, -119, -120, -119, -119, -119,
-119, -120, -119, -118, -119, -119, -119, -120, -118, -120, -118, -119, -119,
-119, -120, -119, -119, -120, -120, -119, -119, -119, -119, -118, -120, -119,
-120, -118, -121, -117, -121, -117, -120, -117, -121, -117, -121, -117, -122,
-115, -5, };