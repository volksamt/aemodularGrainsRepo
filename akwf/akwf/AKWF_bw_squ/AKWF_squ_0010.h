#define DATA_LENGTH 512
#define DATA AKWF_squ_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 125, 116, 122, 116, 121, 117,
121, 117, 121, 118, 120, 118, 121, 118, 120, 119, 119, 118, 119, 119, 119, 119,
118, 120, 119, 120, 119, 120, 119, 119, 118, 120, 119, 120, 119, 119, 119, 119,
118, 119, 120, 118, 119, 118, 120, 119, 120, 119, 119, 119, 119, 118, 119, 120,
118, 118, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 120, 119, 119, 120, 119, 119, 118, 120, 119, 119, 119, 118, 120, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120,
119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119,
119, 120, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 120, 118, 119, 119, 119, 120, 119, 120, 119, 119,
119, 120, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 120, 120, 119, 119, 119, 119, 120, 120,
119, 119, 119, 120, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
120, 120, 119, 119, 119, 119, 118, 120, 118, 119, 119, 119, 118, 120, 118, 120,
118, 120, 118, 120, 119, 119, 118, 119, 119, 119, 120, 118, 120, 117, 122, 115,
123, 114, 126, 111, 127, 105, 127, 43, -127, -107, -126, -115, -122, -118, -120,
-119, -118, -120, -117, -120, -118, -121, -118, -121, -117, -120, -117, -120,
-118, -120, -119, -120, -119, -120, -119, -119, -119, -119, -119, -118, -119,
-118, -120, -118, -120, -118, -120, -119, -120, -118, -120, -119, -120, -119,
-119, -119, -119, -119, -118, -120, -119, -119, -117, -121, -118, -120, -117,
-122, -117, -122, -116, -123, -116, -122, -114, -124, -115, -122, -115, -123,
-114, 105, 127, 113, 125, 114, 124, 115, 123, 116, 122, 117, 122, 117, 120, 118,
120, 118, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
120, 118, 120, 117, 121, 117, 122, 116, 123, 114, 123, 114, 125, 112, 127, 99,
-119, -121, -117, -123, -115, -122, -115, -122, -116, -123, -116, -122, -116,
-121, -117, -121, -117, -120, -117, -120, -119, -120, -118, -119, -119, -119,
-120, -119, -119, -118, -120, -118, -119, -118, -119, -118, -119, -118, -119,
-119, -120, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -118, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -118, -120, -119,
-120, -118, -120, -117, -121, -117, -121, -117, -121, -116, -123, -114, -126,
-101, };