#define DATA_LENGTH 512
#define DATA AKWF_squ_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 92, 76, 59, 67, 71, 67, 66, 68,
68, 68, 68, 68, 68, 67, 67, 68, 68, 68, 68, 68, 67, 68, 68, 67, 68, 68, 68, 68,
67, 68, 67, 67, 68, 68, 68, 67, 68, 68, 68, 68, 68, 68, 68, 68, 67, 67, 68, 68,
68, 68, 68, 67, 67, 68, 68, 67, 68, 67, 67, 68, 68, 68, 68, 67, 68, 67, 68, 68,
68, 68, 69, 68, 68, 68, 68, 67, 67, 68, 68, 67, 68, 68, 67, 68, 68, 68, 68, 67,
67, 68, 68, 68, 67, 68, 68, 68, 68, 68, 67, 67, 68, 68, 68, 68, 68, 68, 67, 68,
68, 68, 68, 67, 68, 68, 68, 68, 67, 68, 67, 69, 68, 67, 67, 68, 68, 68, 67, 68,
68, 67, 68, 68, 67, 68, 67, 68, 67, 68, 68, 67, 67, 68, 68, 67, 68, 68, 68, 68,
67, 68, 68, 67, 68, 68, 67, 68, 68, 68, 68, 67, 67, 68, 68, 68, 68, 67, 67, 68,
68, 68, 68, 68, 67, 68, 68, 68, 68, 67, 68, 68, 68, 68, 68, 68, 68, 67, 68, 68,
68, 68, 67, 68, 68, 67, 68, 68, 68, 68, 68, 67, 68, 67, 68, 68, 67, 68, 68, 68,
68, 68, 68, 67, 67, 68, 68, 67, 67, 67, 68, 67, 68, 67, 68, 67, 68, 67, 68, 67,
68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 67, 69, 66, 68, 67, 68, 66, 69, 67, 69,
67, 69, 66, 69, 67, 68, 68, 67, 68, 67, 68, 66, 67, -104, -78, 5, -84, -83, -66,
-59, -72, -68, -68, -66, -69, -67, -68, -68, -67, -67, -67, -68, -67, -68, -68,
-68, -67, -68, -67, -68, -68, -68, -67, -68, -68, -68, -68, -68, -67, -67, -68,
-68, -67, -67, -68, -68, -68, -68, -68, -67, -68, -67, -68, -68, -68, -68, -68,
-67, -68, -68, -67, -67, -68, -68, -67, -69, -68, -67, -68, -68, -68, -68, -67,
-68, -68, -68, -68, -68, -67, -68, -68, -68, -68, -68, -67, -67, -68, -68, -68,
-68, -68, -68, -68, -68, -69, -69, -68, -68, -68, -68, -67, -68, -68, -68, -67,
-68, -68, -67, -68, -68, -68, -68, -68, -68, -67, -68, -67, -68, -68, -68, -68,
-68, -68, -68, -67, -67, -67, -68, -67, -68, -67, -68, -68, -68, -68, -67, -68,
-67, -68, -68, -68, -68, -67, -68, -68, -68, -67, -69, -68, -67, -68, -68, -68,
-68, -68, -68, -68, -67, -68, -68, -67, -67, -68, -67, -68, -67, -68, -68, -68,
-68, -67, -68, -68, -68, -69, -67, -68, -67, -68, -68, -68, -68, -68, -68, -67,
-68, -67, -68, -68, -67, -67, -68, -68, -69, -68, -67, -68, -68, -68, -68, -67,
-68, -67, -69, -68, -68, -67, -68, -67, -68, -68, -68, -68, -68, -67, -68, -68,
-67, -68, -68, -68, -67, -68, -67, -68, -67, -68, -68, -68, -67, -69, -67, -68,
-68, -68, -67, -67, -68, -67, -68, -67, -69, -66, -70, -65, -72, -64, -73, -59,
-85, 41, 124, -4, };