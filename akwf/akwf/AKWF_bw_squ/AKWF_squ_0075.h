#define DATA_LENGTH 512
#define DATA AKWF_squ_0075

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 9, 13, 17, 21, 25, 28, 31, 34,
38, 41, 45, 48, 51, 55, 59, 62, 66, 69, 73, 77, 80, 83, 87, 91, 94, 97, 101,
104, 107, 111, 115, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 118, 119, 118, 120, 118, 119, 119, 119, 119, 119,
120, 118, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 120, 119, 119, 119,
119, 119, 119, 120, 120, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 120,
119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 120, 120, 120, 119, 119, 120,
119, 119, 119, 120, 120, 119, 119, 118, 118, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120,
119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 120, 118,
118, 119, 119, 119, 120, 120, 119, 119, 118, 120, 119, 119, 119, 119, 119, 120,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119,
119, 120, 120, 119, 118, 119, 118, 120, 119, 119, 118, 120, 119, 119, 119, 119,
120, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 120, 119, 120, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 118, 120, 118, 120, 117, 122,
115, 126, 8, -124, -117, -121, -118, -120, -119, -119, -119, -118, -120, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119,
-119, -119, -119, -119, -120, -118, -119, -119, -118, -120, -119, -119, -120,
-119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -120, -118,
-119, -120, -119, -119, -119, -119, -119, -119, -120, -120, -119, -118, -119,
-119, -119, -120, -120, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -120, -120, -119, -120, -120, -120, -119, -119, -120, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -120, -120, -120,
-120, -118, -119, -119, -119, -118, -119, -120, -118, -120, -118, -119, -119,
-119, -118, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -119, -118, -118, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -118, -118,
-120, -119, -120, -118, -119, -119, -120, -118, -119, -118, -119, -119, -119,
-118, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -120, -118, -119, -118, -120, -118, -120, -117,
-121, -117, -121, -118, -122, -116, -121, -117, -121, -114, -5, };