#define DATA_LENGTH 512
#define DATA AKWF_squ_0098

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 2, 3, 3, 4, 4, 5, 6, 7, 6,
8, 8, 8, 9, 8, 10, 11, 11, 10, 13, 12, 13, 14, 14, 14, 15, 15, 16, 16, 17, 18,
18, 18, 20, 20, 20, 20, 21, 22, 22, 23, 23, 24, 25, 24, 25, 26, 26, 26, 28, 28,
28, 29, 30, 30, 30, 30, 32, 32, 32, 33, 33, 34, 35, 35, 35, 36, 37, 37, 38, 38,
38, 40, 39, 40, 41, 42, 43, 42, 42, 43, 43, 45, 45, 45, 46, 46, 47, 47, 47, 49,
49, 49, 50, 50, 51, 52, 52, 53, 53, 54, 54, 55, 56, 55, 56, 57, 57, 58, 58, 59,
60, 60, 60, 61, 62, 63, 62, 63, 64, 64, 65, 66, 66, 66, 67, 67, 68, 68, 69, 69,
70, 70, 71, 70, 72, 72, 72, 74, 73, 74, 75, 76, 76, 77, 77, 78, 78, 79, 79, 80,
80, 81, 80, 82, 83, 83, 84, 84, 84, 85, 85, 86, 86, 87, 87, 88, 89, 89, 90, 89,
91, 91, 92, 92, 92, 93, 94, 94, 94, 95, 96, 96, 97, 97, 98, 97, 98, 99, 100,
100, 100, 101, 102, 102, 102, 103, 104, 104, 105, 105, 105, 106, 107, 107, 108,
108, 109, 109, 109, 111, 111, 111, 112, 113, 113, 113, 115, 115, 115, 115, 116,
117, 118, 118, 118, 119, 119, 119, 118, 119, 118, 120, 119, 120, 118, 120, 119,
119, 119, 120, 120, 119, 119, 118, 120, 118, 120, 117, 122, 115, 127, 7, -124,
-116, -121, -118, -120, -119, -120, -119, -119, -119, -120, -119, -118, -119,
-118, -120, -118, -119, -119, -120, -118, -120, -119, -120, -118, -119, -119,
-120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -120, -119, -120, -118, -120, -119, -118, -119, -119,
-119, -119, -119, -119, -118, -120, -119, -120, -119, -119, -119, -119, -119,
-120, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -120, -120, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -118, -119, -119, -119, -119, -120, -120, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -118,
-119, -120, -120, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -120, -120, -118, -119, -118, -119, -120, -118,
-119, -120, -119, -119, -119, -120, -119, -119, -118, -119, -119, -120, -119,
-119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119,
-120, -118, -120, -118, -120, -118, -120, -117, -120, -118, -120, -117, -121,
-118, -121, -116, -122, -117, -121, -114, -5, };