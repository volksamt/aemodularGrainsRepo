#define DATA_LENGTH 512
#define DATA AKWF_squ_0084

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 3, 5, 5, 7, 9, 10, 11, 11,
13, 13, 15, 16, 18, 18, 19, 20, 21, 22, 24, 25, 25, 26, 28, 29, 30, 31, 32, 34,
34, 35, 36, 37, 39, 40, 40, 42, 43, 44, 45, 46, 47, 48, 49, 51, 51, 53, 54, 55,
56, 57, 58, 59, 60, 61, 62, 64, 64, 65, 66, 67, 69, 70, 71, 71, 73, 74, 75, 76,
77, 78, 79, 80, 81, 82, 84, 84, 85, 86, 87, 90, 90, 91, 92, 94, 94, 95, 96, 97,
98, 100, 101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 112, 112, 114, 114,
115, 116, 118, 120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 118,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 118, 119, 120, 119,
119, 119, 119, 119, 119, 118, 119, 120, 119, 118, 119, 118, 118, 119, 119, 119,
119, 120, 119, 118, 119, 119, 118, 118, 119, 119, 119, 119, 118, 119, 118, 118,
119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120,
119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 120, 120, 119, 120, 119, 119, 119, 119, 119, 120, 120, 119, 119,
119, 118, 119, 119, 119, 119, 120, 118, 119, 120, 119, 118, 119, 119, 118, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 120,
117, 121, 115, 126, 7, -123, -117, -121, -118, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -118, -119, -119, -120, -118, -119, -119, -119,
-119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -118, -119, -119, -118, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -118, -120, -119,
-119, -119, -120, -119, -118, -119, -119, -118, -119, -119, -118, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120,
-118, -120, -119, -118, -119, -119, -119, -120, -119, -119, -119, -118, -120,
-119, -120, -118, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119,
-118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -118,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -118, -120, -119, -119, -118,
-119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-118, -119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -120, -118,
-119, -118, -119, -119, -118, -119, -118, -119, -118, -119, -118, -120, -118,
-121, -118, -120, -117, -121, -117, -121, -117, -121, -117, -122, -114, -5, };