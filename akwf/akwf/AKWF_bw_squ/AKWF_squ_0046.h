#define DATA_LENGTH 512
#define DATA AKWF_squ_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 43, 97, 119, 117, 117, 116, 114,
114, 114, 113, 113, 112, 111, 110, 110, 109, 108, 108, 107, 107, 106, 105, 105,
104, 104, 103, 102, 96, 57, 3, -19, -19, -18, -18, -18, -17, -18, -17, -17, -17,
-17, -17, -17, -18, -17, -17, -17, -17, -16, -17, -17, -17, -16, -16, -16, -16,
-15, -16, -16, -16, -16, -15, -16, -16, -15, -15, -15, -15, -16, -15, -16, -15,
-15, -15, -15, -15, -15, -14, -15, -14, -14, -14, -14, -14, -14, -14, -14, -13,
-13, -14, -14, -14, -13, -13, -13, -13, -13, -13, -14, -13, -13, -12, -13, -13,
-12, -12, -12, -13, -12, -12, -13, -12, -12, -12, -12, -11, -12, -12, -11, -13,
-12, -12, -12, -11, -12, -11, -11, -11, -11, -11, -12, -12, -11, -10, -11, -10,
-11, -10, -10, -10, -11, -11, -10, -10, -10, -10, -10, -10, -11, -10, -10, -10,
-9, -10, -10, -11, -10, -10, -10, -9, -9, -9, -10, -9, -10, -9, -9, -9, -10, -9,
-9, -9, -10, -10, -9, -8, -9, -9, -9, -8, -9, -8, -8, -8, -8, -8, -7, -7, -8,
-8, -8, -9, -7, -7, -8, -7, -8, -7, -8, -7, -8, -7, -8, -7, -8, -7, -7, -7, -8,
-8, -7, -7, -7, -7, -8, -7, -6, -8, -6, -6, -7, -7, -7, -6, -6, -6, -6, -7, -6,
-7, -7, -7, -7, -5, -7, -6, -5, -7, -6, -6, -6, -5, -6, -6, -6, -6, -6, -6, -5,
-6, -5, -6, -5, -5, -6, -5, -6, -5, -5, -5, -4, -5, -5, -5, -5, -5, -5, -4, -5,
-5, -5, -5, -4, -4, -5, -5, -5, -5, -5, -5, -4, -5, -4, -4, -4, -5, -4, -5, -4,
-4, -3, -4, -4, -4, -4, -4, -4, -5, -4, -4, -5, -4, -4, -4, -5, -3, -4, -3, -4,
-3, -4, -4, -4, -4, -4, -4, -3, -3, -4, -4, -3, -3, -3, -3, -3, -3, -4, -3, -4,
-4, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -2, -3, -2, -4, -3, -3, -3, -3,
-3, -3, -3, -4, -2, -3, -3, -3, -3, -3, -2, -3, -2, -3, -3, -2, -3, -2, -3, -2,
-2, -2, -2, -3, -2, -2, -3, -3, -3, -2, -3, -2, -2, -2, -2, -1, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -1, -2, -2, -1, -1, -1, -2, -2, -1, -1, -2, -1, -2, -2, -2,
-2, -2, -2, -1, -1, -2, -2, -1, -2, -2, -1, -1, -2, -2, -1, -1, -1, -2, -1, -1,
-1, -2, -1, -2, -1, 0, -1, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1,
-1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -2, -1, -1, -1, -1, -1, -1, -1, 0, -1,
-1, 0, -1, -1, -2, -1, -1, -1, -1, 0, -1, 0, -1, 0, -1, 0, -1, 0, 0, 0, 0, -1,
-1, -1, 0, -1, 0, 0, 0, -1, 0, -1, -1, -1, 0, 0, 0, -1, -1, -1, 0, 0, };