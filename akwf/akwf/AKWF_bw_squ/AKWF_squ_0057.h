#define DATA_LENGTH 512
#define DATA AKWF_squ_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1,
2, 2, 2, 1, 1, 2, 1, 2, 2, 2, 2, 2, 2, 3, 3, 3, 2, 2, 3, 3, 4, 4, 3, 4, 4, 4, 3,
4, 4, 4, 3, 4, 5, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 5, 5, 5, 6, 6, 5, 5, 5, 5, 5,
5, 6, 5, 5, 6, 6, 5, 6, 6, 6, 6, 5, 6, 6, 5, 6, 6, 7, 7, 7, 5, 7, 7, 6, 7, 7, 6,
7, 7, 7, 6, 7, 7, 6, 6, 7, 7, 6, 6, 6, 7, 7, 7, 7, 7, 6, 7, 6, 8, 7, 7, 7, 7, 6,
7, 7, 7, 6, 7, 7, 8, 7, 7, 8, 7, 7, 7, 7, 7, 7, 8, 7, 7, 8, 7, 7, 7, 7, 7, 7, 8,
7, 8, 7, 8, 8, 7, 7, 8, 7, 8, 8, 7, 7, 10, 62, 103, 102, 106, 106, 109, 108,
110, 111, 112, 113, 114, 114, 116, 116, 116, 117, 117, 118, 118, 118, 119, 118,
119, 119, 119, 120, 118, 119, 119, 119, 118, 119, 118, 118, 117, 116, 117, 115,
115, 115, 114, 114, 113, 112, 112, 111, 110, 110, 109, 108, 107, 107, 106, 105,
104, 103, 103, 102, 101, 100, 99, 98, 98, 96, 96, 94, 94, 92, 92, 91, 90, 88,
89, 85, 65, 19, -20, -29, -30, -32, -35, -36, -39, -40, -42, -44, -45, -47, -49,
-50, -52, -53, -53, -55, -56, -56, -58, -59, -59, -60, -60, -62, -63, -63, -63,
-64, -64, -65, -65, -66, -66, -66, -67, -66, -67, -66, -66, -67, -67, -67, -68,
-68, -66, -67, -67, -66, -67, -67, -67, -66, -66, -65, -66, -65, -65, -64, -65,
-64, -64, -63, -63, -63, -62, -62, -63, -62, -61, -61, -61, -60, -60, -59, -59,
-58, -59, -58, -58, -58, -56, -56, -56, -56, -55, -54, -54, -54, -53, -52, -52,
-51, -51, -50, -50, -50, -50, -49, -48, -48, -48, -47, -47, -47, -46, -45, -45,
-44, -44, -43, -43, -42, -42, -42, -40, -42, -41, -40, -39, -40, -38, -38, -38,
-37, -36, -36, -37, -36, -35, -35, -34, -34, -33, -33, -33, -32, -32, -31, -32,
-31, -30, -31, -30, -29, -29, -29, -28, -28, -28, -27, -26, -27, -27, -25, -25,
-25, -25, -25, -24, -23, -23, -23, -22, -22, -23, -21, -22, -21, -21, -20, -21,
-20, -20, -19, -19, -18, -18, -18, -17, -18, -17, -17, -16, -17, -16, -16, -15,
-16, -14, -14, -14, -15, -13, -14, -13, -14, -14, -12, -12, -12, -11, -13, -11,
-11, -11, -11, -11, -11, -9, -11, -10, -9, -9, -10, -9, -8, -9, -8, -8, -7, -8,
-7, -7, -8, -6, -7, -7, -6, -7, -5, -6, -6, -6, -5, -4, -5, -4, -5, -5, -4, -4,
-3, -3, -4, -4, -3, -3, -3, -2, -2, -2, -2, -3, -2, -3, -2, -2, -1, -2, -1, -1,
-1, -1, -1, -1, -1, -1, -1, 0, 0, 0, };