#define DATA_LENGTH 512
#define DATA AKWF_squ_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 76, 115, 118, 117, 116, 116, 115,
113, 114, 112, 111, 111, 111, 110, 110, 109, 109, 108, 108, 107, 106, 105, 105,
104, 105, 103, 102, 102, 101, 102, 100, 99, 100, 99, 98, 98, 97, 96, 96, 95, 95,
94, 93, 94, 92, 92, 92, 90, 91, 89, 89, 89, 89, 88, 88, 87, 87, 86, 85, 86, 85,
84, 83, 83, 82, 82, 82, 81, 81, 81, 79, 79, 79, 78, 77, 78, 77, 76, 75, 75, 75,
75, 74, 73, 74, 73, 72, 72, 71, 71, 71, 71, 70, 69, 69, 68, 68, 68, 67, 67, 67,
65, 66, 65, 64, 65, 64, 64, 63, 63, 62, 61, 62, 62, 61, 60, 60, 60, 59, 58, 59,
58, 58, 57, 57, 56, 56, 56, 56, 54, 56, 55, 54, 53, 53, 52, 53, 52, 53, 52, 51,
51, 50, 50, 50, 50, 49, 49, 49, 49, 48, 48, 48, 48, 46, 47, 46, 46, 45, 45, 45,
44, 44, 45, 43, 43, 43, 43, 42, 42, 41, 42, 41, 40, 41, 40, 40, 39, 39, 39, 39,
38, 38, 38, 38, 38, 37, 36, 37, 36, 36, 36, 35, 35, 33, 4, -55, -93, -94, -94,
-94, -93, -93, -92, -91, -92, -90, -90, -90, -89, -88, -88, -87, -87, -87, -86,
-86, -85, -84, -84, -84, -83, -82, -83, -82, -81, -82, -81, -81, -80, -80, -79,
-78, -79, -78, -77, -78, -77, -77, -77, -76, -75, -76, -75, -73, -74, -74, -72,
-72, -71, -71, -71, -71, -71, -70, -69, -69, -68, -69, -68, -68, -68, -66, -66,
-66, -66, -66, -65, -65, -65, -63, -64, -63, -63, -63, -62, -62, -62, -62, -60,
-61, -59, -60, -59, -59, -59, -59, -58, -58, -58, -57, -57, -57, -56, -56, -55,
-55, -54, -55, -54, -54, -54, -53, -53, -52, -53, -52, -51, -51, -51, -50, -51,
-51, -50, -50, -50, -49, -48, -48, -49, -48, -48, -48, -47, -46, -46, -46, -46,
-46, -45, -45, -44, -44, -44, -43, -44, -43, -43, -43, -43, -42, -42, -41, -41,
-41, -42, -41, -40, -40, -40, -41, -40, -40, -39, -39, -38, -38, -38, -38, -38,
-37, -37, -36, -36, -36, -37, -36, -35, -35, -35, -35, -34, -35, -35, -34, -35,
-34, -33, -33, -33, -32, -32, -33, -32, -32, -31, -31, -31, -31, -30, -30, -30,
-30, -30, -30, -30, -29, -29, -28, -28, -28, -28, -28, -28, -27, -28, -27, -27,
-28, -27, -27, -27, -26, -26, -26, -25, -25, -25, -25, -25, -25, -24, -25, -24,
-25, -25, -23, -24, -24, -23, -22, -23, -23, -22, -22, -22, -22, -21, -22, -21,
-21, -21, -21, -21, -21, -20, -20, -19, -20, -20, -20, -19, -19, -19, -20, -18,
-19, -18, -18, -19, -18, -17, -18, -18, -18, -17, -18, -17, -17, -17, -16, -17,
-16, -17, -15, -16, -16, -16, -16, -16, -15, -15, -15, -14, -15, -15, -15, -14,
-14, -14, -14, -13, -14, -14, -13, -13, -14, -13, -14, -12, -12, -12, -13, -12,
-12, -12, -11, -12, -11, -12, -8, };