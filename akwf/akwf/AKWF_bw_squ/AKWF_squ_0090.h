#define DATA_LENGTH 512
#define DATA AKWF_squ_0090

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 3, 4, 5, 5, 6, 7, 8, 9, 9,
10, 11, 11, 12, 13, 14, 15, 15, 16, 17, 17, 18, 19, 19, 21, 21, 22, 22, 24, 25,
25, 26, 26, 27, 28, 28, 29, 30, 30, 31, 33, 33, 33, 34, 35, 36, 36, 37, 38, 39,
40, 40, 42, 42, 42, 44, 44, 45, 45, 46, 47, 48, 49, 50, 50, 51, 52, 53, 52, 54,
54, 55, 56, 57, 58, 58, 59, 59, 60, 61, 62, 63, 63, 64, 64, 65, 66, 67, 68, 68,
69, 70, 70, 71, 72, 73, 73, 74, 74, 76, 76, 77, 78, 79, 79, 80, 80, 81, 83, 83,
84, 84, 85, 86, 86, 87, 88, 88, 89, 90, 91, 92, 93, 93, 93, 95, 95, 96, 96, 98,
98, 99, 101, 101, 101, 102, 103, 103, 104, 105, 106, 107, 108, 108, 108, 109,
110, 111, 112, 112, 113, 114, 115, 115, 116, 116, 117, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 118, 119, 118, 119,
119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 118, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118,
120, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 118, 119,
118, 120, 119, 120, 118, 120, 117, 122, 115, 127, 7, -124, -117, -121, -117,
-119, -118, -119, -119, -119, -118, -119, -119, -119, -120, -119, -120, -119,
-120, -119, -119, -119, -119, -119, -120, -118, -120, -119, -119, -119, -120,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -120, -120, -118,
-119, -118, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -118,
-119, -118, -119, -119, -119, -119, -119, -118, -120, -118, -120, -120, -119,
-119, -120, -118, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -120,
-119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -120, -119,
-119, -120, -119, -119, -120, -118, -118, -119, -119, -120, -118, -120, -118,
-120, -119, -119, -120, -119, -120, -119, -120, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -120, -118, -118, -119, -119, -120, -118, -120, -119,
-118, -119, -119, -119, -120, -119, -118, -119, -118, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-118, -119, -118, -120, -118, -120, -118, -120, -117, -121, -117, -120, -117,
-122, -116, -123, -114, -5, };