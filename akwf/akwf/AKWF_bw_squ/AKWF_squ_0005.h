#define DATA_LENGTH 512
#define DATA AKWF_squ_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 11, 18, 23, 28, 33, 38, 41, 46, 50,
54, 57, 60, 63, 66, 68, 70, 72, 75, 76, 79, 81, 82, 83, 86, 87, 88, 90, 91, 92,
94, 95, 96, 97, 99, 99, 101, 102, 103, 104, 104, 105, 107, 107, 108, 109, 108,
110, 111, 112, 111, 112, 113, 113, 113, 113, 114, 114, 114, 114, 116, 116, 116,
116, 116, 116, 117, 117, 117, 117, 118, 118, 117, 118, 118, 118, 118, 118, 119,
119, 118, 118, 118, 118, 119, 118, 118, 119, 118, 118, 119, 119, 118, 120, 119,
119, 118, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 120, 119, 119,
119, 120, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118,
120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 118, 118, 119, 119, 118, 119, 119, 119,
119, 120, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 118, 119, 119, 119, 119, 119, 120, 120, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 118,
119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 118, 93, 48, 22, 9,
-3, -11, -18, -24, -29, -33, -38, -42, -46, -50, -54, -58, -61, -63, -66, -68,
-71, -73, -75, -76, -78, -80, -82, -83, -85, -86, -88, -90, -92, -93, -94, -96,
-96, -98, -99, -99, -101, -102, -103, -103, -104, -105, -106, -107, -107, -108,
-109, -109, -110, -111, -111, -111, -112, -113, -114, -114, -114, -114, -115,
-115, -115, -116, -115, -117, -116, -116, -116, -117, -116, -116, -117, -118,
-118, -118, -118, -118, -118, -117, -118, -118, -119, -119, -118, -119, -118,
-118, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119,
-118, -119, -119, -119, -118, -119, -120, -118, -119, -120, -119, -119, -119,
-118, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -119, -119, -120, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -120, -119, -120, -119, -119, -118, -119, -118,
-119, -119, -119, -119, -119, -120, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -120, -119, -119, -119, -120, -120, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -120, -119, -119,
-120, -119, -119, -119, -119, -120, -119, -119, -119, -118, -119, -120, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -116, -88, -45, -21,
-8, };