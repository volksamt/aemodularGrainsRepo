#define DATA_LENGTH 512
#define DATA AKWF_squ_0097

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 2, 3, 3, 4, 4, 5, 5, 6, 7, 7,
7, 7, 9, 9, 10, 11, 11, 12, 12, 12, 12, 13, 14, 15, 15, 16, 16, 17, 17, 17, 19,
19, 19, 20, 21, 21, 21, 23, 23, 23, 23, 25, 24, 25, 26, 26, 27, 27, 28, 29, 28,
29, 30, 31, 32, 32, 32, 33, 33, 33, 35, 34, 35, 36, 37, 38, 37, 38, 38, 40, 39,
40, 41, 42, 42, 43, 42, 44, 44, 44, 45, 46, 46, 47, 48, 47, 48, 49, 49, 50, 50,
51, 51, 52, 52, 53, 54, 54, 55, 55, 56, 56, 57, 57, 57, 59, 59, 60, 60, 61, 61,
62, 63, 62, 63, 64, 64, 65, 65, 67, 66, 67, 67, 68, 69, 69, 71, 70, 71, 71, 73,
72, 73, 74, 73, 74, 75, 75, 77, 77, 78, 77, 78, 78, 79, 80, 81, 81, 82, 82, 83,
82, 83, 84, 85, 85, 86, 86, 87, 87, 88, 89, 88, 89, 90, 91, 91, 92, 92, 93, 93,
94, 94, 95, 96, 96, 97, 97, 98, 99, 99, 99, 100, 100, 101, 101, 101, 103, 103,
104, 104, 104, 105, 106, 106, 107, 107, 108, 108, 109, 110, 110, 110, 111, 111,
111, 112, 113, 114, 114, 114, 116, 116, 117, 117, 118, 117, 118, 119, 119, 120,
120, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 120, 119, 120, 118, 120,
118, 119, 120, 119, 120, 120, 119, 119, 120, 118, 120, 118, 122, 115, 127, 7,
-123, -116, -121, -117, -119, -118, -119, -119, -119, -120, -119, -120, -119,
-119, -119, -120, -119, -119, -119, -120, -119, -120, -118, -120, -119, -119,
-118, -119, -119, -119, -119, -120, -119, -120, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -118, -119, -119, -118, -119, -118, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -120, -120, -119, -119, -119, -120, -119, -120,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -120,
-119, -119, -118, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119,
-118, -118, -119, -119, -119, -119, -119, -118, -120, -120, -119, -118, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -120, -119, -120, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119,
-119, -119, -119, -119, -118, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -120, -119, -119, -118, -120, -118, -119,
-119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -120, -117, -120, -118, -120, -118, -120, -118, -121, -118,
-121, -117, -121, -116, -121, -116, -121, -115, -4, };