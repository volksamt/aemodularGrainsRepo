#define DATA_LENGTH 512
#define DATA AKWF_squ_0094

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 3, 3, 5, 5, 5, 6, 7, 7, 8,
9, 9, 9, 11, 11, 11, 12, 13, 13, 14, 14, 15, 16, 17, 17, 18, 18, 19, 20, 20, 20,
21, 22, 22, 24, 23, 25, 25, 26, 26, 27, 27, 28, 28, 30, 29, 30, 30, 32, 32, 33,
33, 34, 34, 34, 36, 37, 38, 37, 39, 38, 39, 39, 41, 40, 42, 42, 43, 44, 44, 45,
45, 46, 46, 47, 48, 49, 48, 50, 51, 51, 52, 52, 53, 53, 54, 55, 55, 56, 56, 56,
57, 58, 58, 59, 60, 60, 61, 62, 62, 64, 64, 64, 64, 65, 66, 67, 67, 69, 69, 69,
70, 70, 71, 72, 73, 73, 73, 75, 74, 76, 76, 77, 77, 78, 78, 79, 80, 80, 81, 81,
82, 83, 83, 83, 85, 85, 85, 86, 87, 87, 88, 88, 89, 90, 91, 91, 92, 92, 93, 94,
94, 94, 95, 97, 97, 97, 98, 97, 99, 100, 100, 100, 102, 102, 103, 103, 104, 104,
104, 106, 107, 107, 107, 109, 109, 109, 110, 110, 111, 111, 112, 113, 113, 114,
115, 115, 116, 117, 117, 118, 118, 119, 118, 118, 119, 119, 119, 119, 118, 120,
118, 119, 119, 120, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 118, 120, 118, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 120, 119, 120, 117,
121, 116, 126, 7, -123, -116, -122, -118, -120, -119, -120, -118, -119, -120,
-119, -118, -118, -120, -119, -120, -119, -119, -119, -119, -119, -120, -119,
-119, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -120, -120, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -118,
-120, -119, -119, -120, -119, -119, -119, -119, -118, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120,
-119, -119, -119, -119, -119, -120, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -120, -119,
-119, -120, -118, -119, -119, -119, -119, -118, -120, -120, -119, -119, -119,
-118, -119, -119, -119, -118, -119, -119, -120, -120, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -120, -118, -119, -119, -119, -120, -119, -120, -120, -118, -120,
-120, -119, -119, -119, -119, -119, -119, -120, -119, -120, -118, -120, -119,
-120, -119, -119, -118, -119, -119, -119, -118, -119, -119, -120, -120, -119,
-119, -119, -119, -119, -120, -119, -120, -119, -120, -118, -121, -118, -120,
-117, -121, -118, -121, -118, -121, -117, -121, -117, -122, -114, -5, };