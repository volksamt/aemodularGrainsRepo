#define DATA_LENGTH 512
#define DATA AKWF_squ_0068

const PROGMEM int8_t DATA[DATA_LENGTH] = {-76, -121, -117, -121, -117, -120,
-118, -120, -118, -120, -118, -120, -118, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -118, -119, -119, -118, -118, -118, -118, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -118, -118, -118, -119, -91, -15, 15, 14,
15, 14, 15, 15, 15, 14, 15, 14, 15, 16, 15, 15, 15, 14, 15, 15, 15, 15, 15, 14,
15, 15, 15, 16, 15, 15, 15, 15, 14, 15, 14, 15, 15, 15, 14, 15, 14, 15, 15, 14,
14, 15, 14, 15, 15, 14, 14, 15, 15, 15, 15, 15, 15, 14, 15, 15, 14, 15, 14, 15,
14, 16, 15, 15, 15, 14, 15, 14, 15, 15, 15, 15, 15, 15, 15, 15, 15, 14, 15, 15,
14, 15, 14, 15, 15, 15, 15, 15, 15, 14, 15, 14, 15, 15, 15, 14, 14, 14, 14, 15,
14, 15, 14, 16, 15, 15, 14, 15, 15, 15, 15, 15, 15, 15, 14, 14, 15, 15, 16, 14,
15, 15, 15, 14, 15, 15, 15, 15, 14, 14, 15, 15, 14, 15, 15, 15, 14, 14, 14, 14,
15, 14, 15, 14, 15, 14, 15, 15, 14, 15, 15, 15, 14, 15, 15, 15, 15, 15, 15, 14,
14, 15, 15, 15, 15, 15, 15, 15, 15, 14, 15, 14, 15, 15, 14, 14, 14, 14, 15, 14,
14, 14, 15, 15, 14, 15, 15, 14, 15, 15, 15, 14, 14, 14, 15, 15, 15, 15, 15, 15,
15, 14, 14, 14, 14, 15, 15, 15, 15, 14, 14, 14, 14, 14, 14, 15, 15, 15, 14, 14,
15, 15, 15, 15, 14, 15, 15, 15, 15, 14, 15, 15, 15, 14, 15, 14, 14, 14, 15, 15,
15, 14, 15, 15, 14, 15, 15, 15, 14, 14, 14, 15, 15, 14, 15, 15, 15, 15, 14, 15,
15, 15, 15, 15, 14, 15, 14, 15, 14, 15, 14, 15, 15, 14, 14, 14, 15, 15, 14, 14,
14, 15, 15, 14, 14, 15, 15, 15, 15, 14, 14, 15, 14, 15, 15, 14, 14, 15, 14, 15,
15, 14, 15, 15, 15, 14, 14, 15, 14, 15, 15, 14, 14, 14, 14, 14, 14, 15, 14, 14,
14, 15, 14, 14, 15, 14, 14, 14, 15, 14, 14, 14, 14, 15, 15, 15, 14, 14, 15, 15,
14, 15, 14, 14, 15, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14,
14, 15, 15, 14, 14, 15, 14, 15, 14, 14, 14, 15, 15, 14, 14, 15, 14, 14, 14, 14,
14, 15, 14, 14, 14, 14, 14, 13, 14, 14, 15, 15, 14, 14, 14, 14, 14, 14, 14, 14,
14, 14, 15, 14, 14, 14, 14, 14, 14, 14, 13, 15, 14, 14, 14, 14, 14, 14, 15, 14,
14, 14, 14, 14, 14, 15, 15, 14, 15, 14, 15, 14, 14, 14, 14, 13, 14, 14, 14, 14,
14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 15, 7, };