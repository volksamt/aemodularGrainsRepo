#define DATA_LENGTH 512
#define DATA AKWF_squ_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 33, 32, 32, 31, 32, 31, 33, 32,
31, 32, 32, 33, 32, 32, 32, 32, 33, 33, 32, 31, 31, 32, 33, 32, 32, 32, 31, 32,
31, 32, 32, 33, 32, 32, 32, 31, 31, 33, 32, 32, 31, 32, 32, 32, 32, 32, 32, 32,
32, 32, 32, 32, 32, 32, 33, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 33,
32, 31, 32, 32, 32, 32, 32, 32, 32, 31, 32, 32, 33, 32, 31, 32, 32, 32, 31, 32,
32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 31, 32, 32, 32, 31, 31, 31, 32, 32, 32,
32, 32, 32, 31, 31, 32, 33, 32, 31, 32, 32, 32, 31, 31, 32, 32, 31, 32, 33, 32,
32, 32, 32, 32, 31, 32, 32, 31, 31, 32, 31, 32, 32, 31, 31, 32, 31, 32, 32, 31,
32, 32, 32, 32, 31, 32, 32, 32, 31, 32, 32, 32, 32, 32, 31, 32, 31, 32, 32, 31,
31, 32, 32, 32, 32, 32, 32, 31, 31, 32, 31, 32, 32, 31, 31, 31, 32, 31, 32, 32,
32, 31, 31, 31, 31, 31, 32, 32, 32, 31, 32, 32, 31, 31, 32, 31, 31, 31, 31, 31,
32, 31, 31, 31, 31, 32, 32, 32, 31, 31, 31, 31, 31, 30, 31, 32, 32, 32, 31, 32,
32, 32, 32, 31, 31, 31, 31, 31, 31, 31, 31, 30, 32, 31, 31, 31, 31, 32, 31, 31,
30, 30, 31, 31, 31, 31, 31, 30, 31, 31, 32, 31, 31, 31, 31, 31, 31, 32, 32, 32,
31, 31, 32, 31, 31, 31, 31, 31, 31, 31, 30, 32, 32, 31, 31, 31, 31, 31, 32, 32,
31, 31, 31, 31, 32, 31, 31, 32, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31,
31, 31, 30, 30, 30, 31, 30, 31, 30, 31, 31, 31, 31, 31, 30, 31, 30, 31, 31, 31,
31, 31, 30, 31, 30, 31, 30, 31, 30, 31, 31, 30, 31, 31, 31, 31, 31, 31, 31, 31,
30, 30, 30, 30, 31, 31, 31, 31, 32, 31, 31, 30, 31, 31, 31, 31, 31, 31, 31, 30,
30, 31, 31, 30, 31, 30, 30, 31, 31, 31, 30, 31, 30, 31, 30, 32, 30, 31, 30, 30,
31, 31, 30, 30, 30, 31, 31, 31, 31, 30, 32, 28, 33, 26, 39, -52, -125, -114,
-123, -117, -122, -117, -120, -118, -119, -119, -120, -119, -119, -119, -119,
-119, -118, -120, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119,
-119, -119, -118, -118, -119, -120, -118, -118, -119, -118, -119, -120, -119,
-119, -118, -119, -119, -118, -119, -118, -118, -118, -119, -118, -119, -118,
-119, -119, -118, -118, -119, -118, -118, -119, -118, -119, -118, -118, -119,
-118, -118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -117, -118, -117, -117, -119, -119, -118, -118, -105,
-38, };