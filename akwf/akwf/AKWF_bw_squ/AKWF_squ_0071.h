#define DATA_LENGTH 512
#define DATA AKWF_squ_0071

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 28, 57, 82, 114, 120, 118, 120,
119, 118, 119, 119, 118, 118, 119, 119, 119, 120, 119, 119, 119, 118, 118, 119,
118, 119, 120, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119,
119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 118,
120, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 120, 119, 119, 119, 120,
119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119,
119, 118, 119, 119, 119, 119, 119, 118, 119, 118, 118, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 120, 120, 119, 118,
120, 119, 119, 120, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120,
119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118,
119, 119, 118, 119, 118, 120, 117, 120, -20, -128, -116, -122, -117, -120, -118,
-120, -118, -119, -118, -119, -119, -119, -119, -119, -120, -119, -120, -119,
-119, -119, -119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -118, -119, -119, -118, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -120, -118, -119, -118, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -120, -118, -119,
-118, -119, -119, -119, -120, -120, -119, -119, -119, -120, -118, -118, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -118, -119, -119,
-118, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -120,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -120, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -120, -119, -118, -119, -119, -119, -119, -120, -119, -119, -120, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -120, -119, -119, -119, -119, -120, -118, -120, -119, -119,
-118, -120, -118, -120, -118, -121, -118, -121, -116, -122, -115, -123, -114,
-127, -101, };