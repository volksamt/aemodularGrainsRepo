#define DATA_LENGTH 512
#define DATA AKWF_squ_0100

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 3, 2, 4, 4, 4, 4, 5, 6, 6,
6, 7, 7, 8, 8, 10, 10, 10, 11, 11, 12, 12, 13, 13, 14, 14, 15, 15, 16, 16, 16,
16, 17, 17, 17, 19, 20, 20, 20, 21, 21, 22, 22, 22, 22, 23, 24, 24, 25, 25, 26,
27, 27, 27, 27, 29, 29, 29, 29, 30, 31, 31, 32, 32, 33, 34, 33, 34, 35, 36, 36,
36, 37, 37, 37, 38, 39, 39, 39, 40, 41, 41, 41, 42, 43, 43, 43, 44, 44, 44, 45,
45, 46, 46, 48, 47, 47, 48, 49, 49, 50, 50, 51, 51, 52, 53, 53, 54, 53, 55, 55,
55, 56, 57, 56, 57, 57, 58, 59, 59, 59, 59, 61, 61, 61, 61, 63, 63, 64, 64, 64,
64, 66, 66, 67, 66, 67, 67, 69, 69, 69, 69, 70, 71, 71, 72, 72, 73, 73, 74, 74,
74, 75, 76, 75, 76, 77, 78, 78, 79, 79, 80, 80, 80, 81, 80, 81, 83, 82, 83, 84,
85, 84, 84, 85, 86, 87, 87, 87, 88, 88, 89, 89, 90, 91, 92, 91, 92, 93, 93, 94,
94, 94, 95, 95, 96, 96, 96, 97, 98, 98, 99, 99, 99, 99, 101, 101, 102, 102, 102,
103, 104, 104, 105, 105, 105, 105, 106, 107, 107, 108, 108, 109, 109, 110, 110,
110, 111, 112, 112, 113, 113, 114, 114, 115, 115, 115, 116, 116, 117, 118, 118,
119, 119, 119, 119, 118, 120, 117, 121, 115, 126, 8, -124, -116, -121, -118,
-120, -118, -120, -119, -119, -119, -118, -120, -119, -119, -119, -119, -118,
-119, -118, -119, -119, -120, -119, -120, -119, -120, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -118, -119,
-118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -120, -120, -119, -118, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-118, -120, -120, -118, -118, -119, -118, -119, -118, -119, -119, -119, -119,
-120, -119, -119, -120, -119, -120, -119, -119, -119, -120, -119, -119, -119,
-118, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -118,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -120, -119, -119,
-119, -120, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119,
-119, -120, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -120,
-118, -120, -118, -120, -118, -121, -118, -120, -117, -121, -117, -121, -117,
-121, -116, -122, -114, -5, };