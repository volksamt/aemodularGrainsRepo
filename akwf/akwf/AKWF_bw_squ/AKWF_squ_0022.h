#define DATA_LENGTH 512
#define DATA AKWF_squ_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {28, 92, 119, 117, 117, 116, 115, 116,
114, 114, 112, 113, 111, 111, 111, 110, 110, 109, 109, 107, 106, 107, 106, 106,
105, 105, 104, 103, 103, 102, 102, 102, 100, 100, 100, 99, 98, 98, 98, 96, 96,
95, 96, 94, 94, 93, 93, 93, 92, 91, 91, 91, 91, 90, 89, 88, 88, 87, 87, 86, 86,
86, 85, 84, 84, 83, 83, 82, 82, 81, 82, 80, 80, 80, 79, 78, 78, 79, 77, 78, 77,
76, 75, 75, 75, 73, 74, 73, 73, 73, 72, 72, 71, 71, 70, 70, 69, 69, 68, 68, 68,
68, 68, 66, 66, 66, 66, 65, 64, 65, 63, 63, 63, 62, 63, 62, 62, 61, 61, 61, 60,
60, 59, 59, 59, 59, 58, 58, 58, 57, 56, 56, 55, 55, 56, 55, 55, 55, 54, 53, 53,
52, 53, 52, 51, 51, 50, 51, 50, 50, 50, 49, 49, 49, 48, 48, 48, 47, 47, 47, 46,
46, 45, 45, 45, 45, 44, 44, 44, 43, 43, 43, 43, 43, 42, 42, 42, 41, 40, 41, 40,
40, 40, 40, 40, 39, 40, 39, 37, 38, 38, 37, 37, 36, 37, 36, 37, 36, 35, 35, 35,
35, 34, 35, 34, 34, 34, 33, 33, 33, 32, 32, 32, 32, 32, 31, 31, 31, 31, 30, 30,
30, 30, 29, 28, 29, 28, 29, 28, 28, 28, 28, 28, 27, 26, 27, 26, 26, 26, 26, 25,
26, 25, 25, 25, 25, 24, 16, -29, -91, -117, -115, -114, -113, -113, -112, -111,
-111, -110, -109, -109, -108, -107, -108, -107, -106, -106, -104, -105, -103,
-102, -103, -102, -102, -102, -101, -100, -100, -99, -98, -98, -97, -96, -97,
-95, -95, -95, -94, -94, -93, -92, -93, -92, -92, -91, -90, -90, -89, -89, -88,
-87, -87, -87, -86, -85, -85, -85, -84, -84, -83, -83, -82, -83, -82, -80, -81,
-79, -79, -79, -78, -79, -78, -77, -77, -77, -76, -75, -75, -75, -75, -74, -73,
-74, -73, -71, -71, -71, -70, -71, -69, -70, -70, -69, -68, -68, -67, -67, -67,
-66, -66, -66, -65, -65, -65, -65, -64, -63, -63, -62, -62, -62, -62, -60, -61,
-61, -60, -60, -59, -59, -58, -58, -58, -57, -56, -57, -56, -56, -55, -55, -55,
-55, -54, -53, -54, -53, -52, -52, -52, -52, -51, -50, -51, -50, -50, -50, -49,
-49, -50, -48, -48, -48, -47, -48, -47, -47, -47, -46, -46, -46, -45, -45, -45,
-44, -45, -43, -44, -42, -42, -42, -42, -42, -41, -41, -41, -41, -40, -41, -40,
-40, -39, -39, -39, -39, -39, -38, -38, -37, -38, -37, -37, -36, -36, -37, -36,
-36, -36, -35, -35, -34, -35, -34, -34, -33, -33, -32, -32, -32, -32, -32, -32,
-31, -32, -32, -30, -31, -30, -31, -30, -30, -30, -28, -29, -28, -28, -28, -28,
-28, -28, -27, -28, -28, -26, -26, -26, -26, -26, -26, -26, -25, -25, -24, -25,
-25, -24, -25, -24, -24, -23, -24, -23, -23, -23, -22, -23, -23, -22, -21, -22,
-22, -21, -22, -11, };